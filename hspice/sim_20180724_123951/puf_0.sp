** Generated by pufgen.py for: hspiceD
** Generated on: 07/24/18 12:39:51
** Design library name: pufLib
** Design cell name: puf_0
** Design view name: schematic

** Library name: pufLib
** Cell name: puf_0
** View name: schematic
.subckt puf_0 ch_0 ch_1 ch_2 ch_3 ch_4 ch_5 ch_6 ch_7 ch_8 ch_9 ch_10 ch_11 ch_12 ch_13 ch_14 ch_15 ch_16 ch_17 ch_18 ch_19 ch_20 ch_21 ch_22 ch_23 ch_24 ch_25 ch_26 ch_27 ch_28 ch_29 ch_30 ch_31 ch_32 ch_33 ch_34 ch_35 ch_36 ch_37 ch_38 ch_39 ch_40 ch_41 ch_42 ch_43 ch_44 ch_45 ch_46 ch_47 ch_48 ch_49 ch_50 ch_51 ch_52 ch_53 ch_54 ch_55 ch_56 ch_57 ch_58 ch_59 ch_60 ch_61 ch_62 ch_63 ch_64 ch_65 ch_66 ch_67 ch_68 ch_69 ch_70 ch_71 ch_72 ch_73 ch_74 ch_75 ch_76 ch_77 ch_78 ch_79 ch_80 ch_81 ch_82 ch_83 ch_84 ch_85 ch_86 ch_87 ch_88 ch_89 ch_90 ch_91 ch_92 ch_93 ch_94 ch_95 ch_96 ch_97 ch_98 ch_99 ch_100 ch_101 ch_102 ch_103 ch_104 ch_105 ch_106 ch_107 ch_108 ch_109 ch_110 ch_111 ch_112 ch_113 ch_114 ch_115 ch_116 ch_117 ch_118 ch_119 ch_120 ch_121 ch_122 ch_123 ch_124 ch_125 ch_126 ch_127 gnd in_sig q vdd
** 1 PUF stage
xi0 gnd in_sig in_sig ch_0 net2 net3 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.110 mup_inv_npvth=0.079
+mup_na_ppvth_lt=-0.272 mup_na_ppvth_rt=-0.196 mup_na_npvth_up=0.231 mup_na_npvth_dn=0.182
+mup_nb_ppvth_lt=-0.238 mup_nb_ppvth_rt=-0.178 mup_nb_npvth_up=0.731 mup_nb_npvth_dn=0.290
+mup_no_ppvth_lt=-0.156 mup_no_ppvth_rt=-0.003 mup_no_npvth_up=0.212 mup_no_npvth_dn=0.186

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.347 mdn_inv_npvth=0.156
+mdn_na_ppvth_lt=-0.808 mdn_na_ppvth_rt=-0.239 mdn_na_npvth_up=0.554 mdn_na_npvth_dn=0.587
+mdn_nb_ppvth_lt=-0.262 mdn_nb_ppvth_rt=-0.212 mdn_nb_npvth_up=0.126 mdn_nb_npvth_dn=0.745
+mdn_no_ppvth_lt=-0.453 mdn_no_ppvth_rt=-0.199 mdn_no_npvth_up=0.639 mdn_no_npvth_dn=0.081
**

** 2 PUF stage
xi1 gnd net2 net3 ch_1 net4 net5 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.283 mup_inv_npvth=0.107
+mup_na_ppvth_lt=-0.331 mup_na_ppvth_rt=-0.089 mup_na_npvth_up=0.520 mup_na_npvth_dn=0.400
+mup_nb_ppvth_lt=-0.672 mup_nb_ppvth_rt=-0.075 mup_nb_npvth_up=0.734 mup_nb_npvth_dn=0.082
+mup_no_ppvth_lt=-0.125 mup_no_ppvth_rt=-0.123 mup_no_npvth_up=0.156 mup_no_npvth_dn=0.301

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.401 mdn_inv_npvth=0.175
+mdn_na_ppvth_lt=-0.042 mdn_na_ppvth_rt=-0.782 mdn_na_npvth_up=0.702 mdn_na_npvth_dn=0.141
+mdn_nb_ppvth_lt=-0.056 mdn_nb_ppvth_rt=-0.197 mdn_nb_npvth_up=0.232 mdn_nb_npvth_dn=0.368
+mdn_no_ppvth_lt=-0.341 mdn_no_ppvth_rt=-0.125 mdn_no_npvth_up=0.190 mdn_no_npvth_dn=0.221
**

** 3 PUF stage
xi2 gnd net4 net5 ch_2 net6 net7 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.386 mup_inv_npvth=0.604
+mup_na_ppvth_lt=-0.064 mup_na_ppvth_rt=-0.028 mup_na_npvth_up=0.205 mup_na_npvth_dn=0.248
+mup_nb_ppvth_lt=-0.263 mup_nb_ppvth_rt=-0.119 mup_nb_npvth_up=0.792 mup_nb_npvth_dn=0.895
+mup_no_ppvth_lt=-0.912 mup_no_ppvth_rt=-0.054 mup_no_npvth_up=0.189 mup_no_npvth_dn=0.154

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.173 mdn_inv_npvth=0.025
+mdn_na_ppvth_lt=-0.421 mdn_na_ppvth_rt=-0.126 mdn_na_npvth_up=0.337 mdn_na_npvth_dn=0.078
+mdn_nb_ppvth_lt=-0.271 mdn_nb_ppvth_rt=-0.239 mdn_nb_npvth_up=0.216 mdn_nb_npvth_dn=0.438
+mdn_no_ppvth_lt=-0.091 mdn_no_ppvth_rt=-0.181 mdn_no_npvth_up=0.831 mdn_no_npvth_dn=0.021
**

** 4 PUF stage
xi3 gnd net6 net7 ch_3 net8 net9 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.310 mup_inv_npvth=0.528
+mup_na_ppvth_lt=-0.052 mup_na_ppvth_rt=-0.021 mup_na_npvth_up=0.557 mup_na_npvth_dn=0.094
+mup_nb_ppvth_lt=-0.237 mup_nb_ppvth_rt=-0.152 mup_nb_npvth_up=0.671 mup_nb_npvth_dn=0.232
+mup_no_ppvth_lt=-0.324 mup_no_ppvth_rt=-0.112 mup_no_npvth_up=0.315 mup_no_npvth_dn=0.253

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.241 mdn_inv_npvth=0.475
+mdn_na_ppvth_lt=-0.000 mdn_na_ppvth_rt=-0.270 mdn_na_npvth_up=0.259 mdn_na_npvth_dn=0.091
+mdn_nb_ppvth_lt=-0.013 mdn_nb_ppvth_rt=-0.234 mdn_nb_npvth_up=0.075 mdn_nb_npvth_dn=0.045
+mdn_no_ppvth_lt=-0.078 mdn_no_ppvth_rt=-0.050 mdn_no_npvth_up=0.535 mdn_no_npvth_dn=0.796
**

** 5 PUF stage
xi4 gnd net8 net9 ch_4 net10 net11 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.749 mup_inv_npvth=0.184
+mup_na_ppvth_lt=-0.259 mup_na_ppvth_rt=-0.264 mup_na_npvth_up=0.073 mup_na_npvth_dn=0.145
+mup_nb_ppvth_lt=-0.326 mup_nb_ppvth_rt=-0.053 mup_nb_npvth_up=0.289 mup_nb_npvth_dn=0.244
+mup_no_ppvth_lt=-0.092 mup_no_ppvth_rt=-0.592 mup_no_npvth_up=0.148 mup_no_npvth_dn=0.589

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.209 mdn_inv_npvth=0.058
+mdn_na_ppvth_lt=-0.361 mdn_na_ppvth_rt=-0.268 mdn_na_npvth_up=0.161 mdn_na_npvth_dn=0.567
+mdn_nb_ppvth_lt=-0.157 mdn_nb_ppvth_rt=-0.709 mdn_nb_npvth_up=0.347 mdn_nb_npvth_dn=0.490
+mdn_no_ppvth_lt=-0.304 mdn_no_ppvth_rt=-0.571 mdn_no_npvth_up=0.115 mdn_no_npvth_dn=0.485
**

** 6 PUF stage
xi5 gnd net10 net11 ch_5 net12 net13 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.392 mup_inv_npvth=0.433
+mup_na_ppvth_lt=-0.343 mup_na_ppvth_rt=-0.510 mup_na_npvth_up=0.548 mup_na_npvth_dn=0.046
+mup_nb_ppvth_lt=-0.266 mup_nb_ppvth_rt=-0.273 mup_nb_npvth_up=0.848 mup_nb_npvth_dn=0.154
+mup_no_ppvth_lt=-0.752 mup_no_ppvth_rt=-0.446 mup_no_npvth_up=0.206 mup_no_npvth_dn=0.586

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.210 mdn_inv_npvth=0.434
+mdn_na_ppvth_lt=-0.315 mdn_na_ppvth_rt=-0.622 mdn_na_npvth_up=0.304 mdn_na_npvth_dn=0.058
+mdn_nb_ppvth_lt=-0.415 mdn_nb_ppvth_rt=-0.338 mdn_nb_npvth_up=0.520 mdn_nb_npvth_dn=0.699
+mdn_no_ppvth_lt=-0.157 mdn_no_ppvth_rt=-0.200 mdn_no_npvth_up=0.771 mdn_no_npvth_dn=0.433
**

** 7 PUF stage
xi6 gnd net12 net13 ch_6 net14 net15 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.116 mup_inv_npvth=0.097
+mup_na_ppvth_lt=-0.532 mup_na_ppvth_rt=-0.254 mup_na_npvth_up=0.524 mup_na_npvth_dn=0.177
+mup_nb_ppvth_lt=-0.174 mup_nb_ppvth_rt=-0.031 mup_nb_npvth_up=0.677 mup_nb_npvth_dn=0.188
+mup_no_ppvth_lt=-0.545 mup_no_ppvth_rt=-0.345 mup_no_npvth_up=0.014 mup_no_npvth_dn=0.244

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.256 mdn_inv_npvth=0.141
+mdn_na_ppvth_lt=-0.623 mdn_na_ppvth_rt=-0.463 mdn_na_npvth_up=0.192 mdn_na_npvth_dn=0.629
+mdn_nb_ppvth_lt=-0.228 mdn_nb_ppvth_rt=-0.657 mdn_nb_npvth_up=0.417 mdn_nb_npvth_dn=0.285
+mdn_no_ppvth_lt=-0.350 mdn_no_ppvth_rt=-0.163 mdn_no_npvth_up=0.049 mdn_no_npvth_dn=0.544
**

** 8 PUF stage
xi7 gnd net14 net15 ch_7 net16 net17 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.764 mup_inv_npvth=1.501
+mup_na_ppvth_lt=-0.443 mup_na_ppvth_rt=-0.361 mup_na_npvth_up=0.178 mup_na_npvth_dn=0.248
+mup_nb_ppvth_lt=-0.464 mup_nb_ppvth_rt=-0.025 mup_nb_npvth_up=0.337 mup_nb_npvth_dn=0.233
+mup_no_ppvth_lt=-0.622 mup_no_ppvth_rt=-0.281 mup_no_npvth_up=0.111 mup_no_npvth_dn=0.269

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.104 mdn_inv_npvth=0.061
+mdn_na_ppvth_lt=-0.332 mdn_na_ppvth_rt=-0.191 mdn_na_npvth_up=0.100 mdn_na_npvth_dn=0.303
+mdn_nb_ppvth_lt=-0.387 mdn_nb_ppvth_rt=-0.056 mdn_nb_npvth_up=0.037 mdn_nb_npvth_dn=0.341
+mdn_no_ppvth_lt=-0.446 mdn_no_ppvth_rt=-0.026 mdn_no_npvth_up=0.122 mdn_no_npvth_dn=0.761
**

** 9 PUF stage
xi8 gnd net16 net17 ch_8 net18 net19 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.386 mup_inv_npvth=0.010
+mup_na_ppvth_lt=-0.168 mup_na_ppvth_rt=-0.306 mup_na_npvth_up=0.648 mup_na_npvth_dn=0.812
+mup_nb_ppvth_lt=-0.080 mup_nb_ppvth_rt=-0.626 mup_nb_npvth_up=0.860 mup_nb_npvth_dn=0.451
+mup_no_ppvth_lt=-0.544 mup_no_ppvth_rt=-0.211 mup_no_npvth_up=0.123 mup_no_npvth_dn=0.074

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.012 mdn_inv_npvth=0.138
+mdn_na_ppvth_lt=-0.012 mdn_na_ppvth_rt=-0.254 mdn_na_npvth_up=0.262 mdn_na_npvth_dn=0.013
+mdn_nb_ppvth_lt=-0.437 mdn_nb_ppvth_rt=-0.575 mdn_nb_npvth_up=0.381 mdn_nb_npvth_dn=0.424
+mdn_no_ppvth_lt=-0.516 mdn_no_ppvth_rt=-0.062 mdn_no_npvth_up=0.124 mdn_no_npvth_dn=0.189
**

** 10 PUF stage
xi9 gnd net18 net19 ch_9 net20 net21 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.142 mup_inv_npvth=0.361
+mup_na_ppvth_lt=-0.124 mup_na_ppvth_rt=-0.258 mup_na_npvth_up=0.405 mup_na_npvth_dn=0.431
+mup_nb_ppvth_lt=-0.432 mup_nb_ppvth_rt=-0.514 mup_nb_npvth_up=0.247 mup_nb_npvth_dn=0.139
+mup_no_ppvth_lt=-0.119 mup_no_ppvth_rt=-0.343 mup_no_npvth_up=0.314 mup_no_npvth_dn=0.148

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.463 mdn_inv_npvth=0.176
+mdn_na_ppvth_lt=-0.859 mdn_na_ppvth_rt=-0.508 mdn_na_npvth_up=0.346 mdn_na_npvth_dn=0.488
+mdn_nb_ppvth_lt=-0.564 mdn_nb_ppvth_rt=-0.007 mdn_nb_npvth_up=0.088 mdn_nb_npvth_dn=0.056
+mdn_no_ppvth_lt=-0.410 mdn_no_ppvth_rt=-1.312 mdn_no_npvth_up=0.204 mdn_no_npvth_dn=0.330
**

** 11 PUF stage
xi10 gnd net20 net21 ch_10 net22 net23 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.048 mup_inv_npvth=0.144
+mup_na_ppvth_lt=-0.322 mup_na_ppvth_rt=-0.596 mup_na_npvth_up=0.288 mup_na_npvth_dn=0.153
+mup_nb_ppvth_lt=-0.696 mup_nb_ppvth_rt=-0.163 mup_nb_npvth_up=0.224 mup_nb_npvth_dn=0.451
+mup_no_ppvth_lt=-0.410 mup_no_ppvth_rt=-0.701 mup_no_npvth_up=0.539 mup_no_npvth_dn=0.479

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.232 mdn_inv_npvth=0.872
+mdn_na_ppvth_lt=-0.062 mdn_na_ppvth_rt=-0.122 mdn_na_npvth_up=0.035 mdn_na_npvth_dn=0.579
+mdn_nb_ppvth_lt=-0.542 mdn_nb_ppvth_rt=-0.095 mdn_nb_npvth_up=0.791 mdn_nb_npvth_dn=0.181
+mdn_no_ppvth_lt=-0.575 mdn_no_ppvth_rt=-0.269 mdn_no_npvth_up=0.620 mdn_no_npvth_dn=0.251
**

** 12 PUF stage
xi11 gnd net22 net23 ch_11 net24 net25 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.354 mup_inv_npvth=0.304
+mup_na_ppvth_lt=-0.080 mup_na_ppvth_rt=-0.813 mup_na_npvth_up=0.012 mup_na_npvth_dn=0.294
+mup_nb_ppvth_lt=-0.221 mup_nb_ppvth_rt=-0.292 mup_nb_npvth_up=0.326 mup_nb_npvth_dn=0.855
+mup_no_ppvth_lt=-0.412 mup_no_ppvth_rt=-0.842 mup_no_npvth_up=1.632 mup_no_npvth_dn=0.155

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.560 mdn_inv_npvth=0.649
+mdn_na_ppvth_lt=-0.542 mdn_na_ppvth_rt=-0.074 mdn_na_npvth_up=0.356 mdn_na_npvth_dn=0.635
+mdn_nb_ppvth_lt=-0.038 mdn_nb_ppvth_rt=-0.506 mdn_nb_npvth_up=0.637 mdn_nb_npvth_dn=0.432
+mdn_no_ppvth_lt=-0.100 mdn_no_ppvth_rt=-0.010 mdn_no_npvth_up=0.004 mdn_no_npvth_dn=0.671
**

** 13 PUF stage
xi12 gnd net24 net25 ch_12 net26 net27 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.842 mup_inv_npvth=0.459
+mup_na_ppvth_lt=-0.347 mup_na_ppvth_rt=-0.169 mup_na_npvth_up=0.110 mup_na_npvth_dn=0.209
+mup_nb_ppvth_lt=-0.022 mup_nb_ppvth_rt=-0.397 mup_nb_npvth_up=0.282 mup_nb_npvth_dn=0.624
+mup_no_ppvth_lt=-0.408 mup_no_ppvth_rt=-0.379 mup_no_npvth_up=0.425 mup_no_npvth_dn=0.593

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.560 mdn_inv_npvth=0.117
+mdn_na_ppvth_lt=-0.413 mdn_na_ppvth_rt=-0.534 mdn_na_npvth_up=0.013 mdn_na_npvth_dn=0.466
+mdn_nb_ppvth_lt=-0.234 mdn_nb_ppvth_rt=-0.328 mdn_nb_npvth_up=0.286 mdn_nb_npvth_dn=0.645
+mdn_no_ppvth_lt=-0.355 mdn_no_ppvth_rt=-0.240 mdn_no_npvth_up=0.094 mdn_no_npvth_dn=0.712
**

** 14 PUF stage
xi13 gnd net26 net27 ch_13 net28 net29 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.913 mup_inv_npvth=0.851
+mup_na_ppvth_lt=-0.290 mup_na_ppvth_rt=-0.589 mup_na_npvth_up=0.561 mup_na_npvth_dn=0.678
+mup_nb_ppvth_lt=-0.917 mup_nb_ppvth_rt=-0.906 mup_nb_npvth_up=0.039 mup_nb_npvth_dn=0.335
+mup_no_ppvth_lt=-0.542 mup_no_ppvth_rt=-0.421 mup_no_npvth_up=0.003 mup_no_npvth_dn=0.452

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.355 mdn_inv_npvth=0.066
+mdn_na_ppvth_lt=-0.073 mdn_na_ppvth_rt=-0.071 mdn_na_npvth_up=0.315 mdn_na_npvth_dn=0.147
+mdn_nb_ppvth_lt=-0.038 mdn_nb_ppvth_rt=-0.241 mdn_nb_npvth_up=0.788 mdn_nb_npvth_dn=0.090
+mdn_no_ppvth_lt=-0.004 mdn_no_ppvth_rt=-0.080 mdn_no_npvth_up=0.087 mdn_no_npvth_dn=0.197
**

** 15 PUF stage
xi14 gnd net28 net29 ch_14 net30 net31 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.646 mup_inv_npvth=0.433
+mup_na_ppvth_lt=-0.183 mup_na_ppvth_rt=-0.084 mup_na_npvth_up=0.020 mup_na_npvth_dn=0.095
+mup_nb_ppvth_lt=-0.188 mup_nb_ppvth_rt=-0.771 mup_nb_npvth_up=0.642 mup_nb_npvth_dn=0.375
+mup_no_ppvth_lt=-0.368 mup_no_ppvth_rt=-0.087 mup_no_npvth_up=0.343 mup_no_npvth_dn=0.134

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.012 mdn_inv_npvth=0.106
+mdn_na_ppvth_lt=-0.080 mdn_na_ppvth_rt=-0.389 mdn_na_npvth_up=0.838 mdn_na_npvth_dn=0.298
+mdn_nb_ppvth_lt=-0.026 mdn_nb_ppvth_rt=-0.074 mdn_nb_npvth_up=0.057 mdn_nb_npvth_dn=0.957
+mdn_no_ppvth_lt=-0.353 mdn_no_ppvth_rt=-0.253 mdn_no_npvth_up=0.288 mdn_no_npvth_dn=0.271
**

** 16 PUF stage
xi15 gnd net30 net31 ch_15 net32 net33 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.522 mup_inv_npvth=0.413
+mup_na_ppvth_lt=-0.136 mup_na_ppvth_rt=-0.626 mup_na_npvth_up=0.197 mup_na_npvth_dn=0.383
+mup_nb_ppvth_lt=-0.237 mup_nb_ppvth_rt=-0.395 mup_nb_npvth_up=0.249 mup_nb_npvth_dn=0.009
+mup_no_ppvth_lt=-0.122 mup_no_ppvth_rt=-0.502 mup_no_npvth_up=0.418 mup_no_npvth_dn=0.689

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.439 mdn_inv_npvth=0.130
+mdn_na_ppvth_lt=-0.462 mdn_na_ppvth_rt=-0.679 mdn_na_npvth_up=0.244 mdn_na_npvth_dn=0.812
+mdn_nb_ppvth_lt=-0.069 mdn_nb_ppvth_rt=-0.482 mdn_nb_npvth_up=0.079 mdn_nb_npvth_dn=0.190
+mdn_no_ppvth_lt=-0.168 mdn_no_ppvth_rt=-0.180 mdn_no_npvth_up=0.334 mdn_no_npvth_dn=0.152
**

** 17 PUF stage
xi16 gnd net32 net33 ch_16 net34 net35 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.064 mup_inv_npvth=0.154
+mup_na_ppvth_lt=-0.352 mup_na_ppvth_rt=-0.347 mup_na_npvth_up=0.424 mup_na_npvth_dn=0.644
+mup_nb_ppvth_lt=-0.709 mup_nb_ppvth_rt=-0.184 mup_nb_npvth_up=0.210 mup_nb_npvth_dn=0.399
+mup_no_ppvth_lt=-0.767 mup_no_ppvth_rt=-0.261 mup_no_npvth_up=0.216 mup_no_npvth_dn=0.473

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.147 mdn_inv_npvth=0.373
+mdn_na_ppvth_lt=-0.425 mdn_na_ppvth_rt=-0.513 mdn_na_npvth_up=0.264 mdn_na_npvth_dn=0.057
+mdn_nb_ppvth_lt=-0.615 mdn_nb_ppvth_rt=-0.456 mdn_nb_npvth_up=0.696 mdn_nb_npvth_dn=0.304
+mdn_no_ppvth_lt=-0.663 mdn_no_ppvth_rt=-0.174 mdn_no_npvth_up=0.047 mdn_no_npvth_dn=0.738
**

** 18 PUF stage
xi17 gnd net34 net35 ch_17 net36 net37 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.120 mup_inv_npvth=0.572
+mup_na_ppvth_lt=-0.176 mup_na_ppvth_rt=-0.019 mup_na_npvth_up=0.546 mup_na_npvth_dn=0.709
+mup_nb_ppvth_lt=-0.230 mup_nb_ppvth_rt=-0.562 mup_nb_npvth_up=0.301 mup_nb_npvth_dn=0.830
+mup_no_ppvth_lt=-0.135 mup_no_ppvth_rt=-0.278 mup_no_npvth_up=0.398 mup_no_npvth_dn=0.062

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-1.032 mdn_inv_npvth=0.789
+mdn_na_ppvth_lt=-0.259 mdn_na_ppvth_rt=-0.403 mdn_na_npvth_up=0.284 mdn_na_npvth_dn=0.869
+mdn_nb_ppvth_lt=-0.538 mdn_nb_ppvth_rt=-0.741 mdn_nb_npvth_up=0.281 mdn_nb_npvth_dn=0.455
+mdn_no_ppvth_lt=-0.101 mdn_no_ppvth_rt=-0.244 mdn_no_npvth_up=0.006 mdn_no_npvth_dn=0.384
**

** 19 PUF stage
xi18 gnd net36 net37 ch_18 net38 net39 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.047 mup_inv_npvth=1.044
+mup_na_ppvth_lt=-0.725 mup_na_ppvth_rt=-0.140 mup_na_npvth_up=0.831 mup_na_npvth_dn=0.863
+mup_nb_ppvth_lt=-0.193 mup_nb_ppvth_rt=-0.003 mup_nb_npvth_up=0.681 mup_nb_npvth_dn=0.509
+mup_no_ppvth_lt=-0.450 mup_no_ppvth_rt=-0.353 mup_no_npvth_up=0.445 mup_no_npvth_dn=0.106

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.113 mdn_inv_npvth=0.648
+mdn_na_ppvth_lt=-0.236 mdn_na_ppvth_rt=-0.760 mdn_na_npvth_up=0.297 mdn_na_npvth_dn=0.442
+mdn_nb_ppvth_lt=-0.075 mdn_nb_ppvth_rt=-0.409 mdn_nb_npvth_up=0.188 mdn_nb_npvth_dn=0.044
+mdn_no_ppvth_lt=-0.154 mdn_no_ppvth_rt=-0.053 mdn_no_npvth_up=0.118 mdn_no_npvth_dn=0.311
**

** 20 PUF stage
xi19 gnd net38 net39 ch_19 net40 net41 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.012 mup_inv_npvth=0.129
+mup_na_ppvth_lt=-0.173 mup_na_ppvth_rt=-0.076 mup_na_npvth_up=0.252 mup_na_npvth_dn=0.389
+mup_nb_ppvth_lt=-0.376 mup_nb_ppvth_rt=-0.449 mup_nb_npvth_up=0.108 mup_nb_npvth_dn=1.039
+mup_no_ppvth_lt=-0.053 mup_no_ppvth_rt=-0.089 mup_no_npvth_up=0.033 mup_no_npvth_dn=0.504

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.276 mdn_inv_npvth=0.128
+mdn_na_ppvth_lt=-0.065 mdn_na_ppvth_rt=-0.186 mdn_na_npvth_up=0.521 mdn_na_npvth_dn=0.082
+mdn_nb_ppvth_lt=-0.085 mdn_nb_ppvth_rt=-0.086 mdn_nb_npvth_up=0.078 mdn_nb_npvth_dn=0.594
+mdn_no_ppvth_lt=-0.226 mdn_no_ppvth_rt=-1.010 mdn_no_npvth_up=0.377 mdn_no_npvth_dn=0.058
**

** 21 PUF stage
xi20 gnd net40 net41 ch_20 net42 net43 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.036 mup_inv_npvth=0.507
+mup_na_ppvth_lt=-0.372 mup_na_ppvth_rt=-0.536 mup_na_npvth_up=0.012 mup_na_npvth_dn=0.452
+mup_nb_ppvth_lt=-0.286 mup_nb_ppvth_rt=-0.006 mup_nb_npvth_up=0.625 mup_nb_npvth_dn=0.265
+mup_no_ppvth_lt=-0.217 mup_no_ppvth_rt=-0.630 mup_no_npvth_up=0.759 mup_no_npvth_dn=0.462

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.519 mdn_inv_npvth=0.364
+mdn_na_ppvth_lt=-0.412 mdn_na_ppvth_rt=-0.764 mdn_na_npvth_up=0.375 mdn_na_npvth_dn=0.447
+mdn_nb_ppvth_lt=-0.373 mdn_nb_ppvth_rt=-0.115 mdn_nb_npvth_up=0.085 mdn_nb_npvth_dn=0.135
+mdn_no_ppvth_lt=-0.543 mdn_no_ppvth_rt=-0.415 mdn_no_npvth_up=0.057 mdn_no_npvth_dn=0.293
**

** 22 PUF stage
xi21 gnd net42 net43 ch_21 net44 net45 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.579 mup_inv_npvth=0.564
+mup_na_ppvth_lt=-0.344 mup_na_ppvth_rt=-0.008 mup_na_npvth_up=0.567 mup_na_npvth_dn=0.271
+mup_nb_ppvth_lt=-0.705 mup_nb_ppvth_rt=-0.048 mup_nb_npvth_up=0.027 mup_nb_npvth_dn=0.006
+mup_no_ppvth_lt=-0.604 mup_no_ppvth_rt=-0.594 mup_no_npvth_up=0.562 mup_no_npvth_dn=0.329

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.050 mdn_inv_npvth=0.471
+mdn_na_ppvth_lt=-0.369 mdn_na_ppvth_rt=-0.142 mdn_na_npvth_up=0.036 mdn_na_npvth_dn=0.275
+mdn_nb_ppvth_lt=-0.303 mdn_nb_ppvth_rt=-0.292 mdn_nb_npvth_up=0.031 mdn_nb_npvth_dn=0.529
+mdn_no_ppvth_lt=-0.340 mdn_no_ppvth_rt=-0.529 mdn_no_npvth_up=0.661 mdn_no_npvth_dn=0.280
**

** 23 PUF stage
xi22 gnd net44 net45 ch_22 net46 net47 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.049 mup_inv_npvth=0.059
+mup_na_ppvth_lt=-0.510 mup_na_ppvth_rt=-0.359 mup_na_npvth_up=0.150 mup_na_npvth_dn=0.010
+mup_nb_ppvth_lt=-0.299 mup_nb_ppvth_rt=-0.742 mup_nb_npvth_up=0.053 mup_nb_npvth_dn=0.482
+mup_no_ppvth_lt=-0.116 mup_no_ppvth_rt=-0.013 mup_no_npvth_up=0.712 mup_no_npvth_dn=0.508

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.091 mdn_inv_npvth=0.223
+mdn_na_ppvth_lt=-0.124 mdn_na_ppvth_rt=-0.204 mdn_na_npvth_up=0.456 mdn_na_npvth_dn=0.303
+mdn_nb_ppvth_lt=-0.705 mdn_nb_ppvth_rt=-0.598 mdn_nb_npvth_up=0.410 mdn_nb_npvth_dn=0.566
+mdn_no_ppvth_lt=-0.139 mdn_no_ppvth_rt=-0.532 mdn_no_npvth_up=0.044 mdn_no_npvth_dn=0.299
**

** 24 PUF stage
xi23 gnd net46 net47 ch_23 net48 net49 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.152 mup_inv_npvth=0.575
+mup_na_ppvth_lt=-0.532 mup_na_ppvth_rt=-0.397 mup_na_npvth_up=0.026 mup_na_npvth_dn=0.056
+mup_nb_ppvth_lt=-0.340 mup_nb_ppvth_rt=-0.418 mup_nb_npvth_up=0.272 mup_nb_npvth_dn=0.231
+mup_no_ppvth_lt=-0.022 mup_no_ppvth_rt=-0.381 mup_no_npvth_up=0.271 mup_no_npvth_dn=0.216

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.620 mdn_inv_npvth=0.594
+mdn_na_ppvth_lt=-0.108 mdn_na_ppvth_rt=-0.224 mdn_na_npvth_up=0.105 mdn_na_npvth_dn=0.759
+mdn_nb_ppvth_lt=-0.573 mdn_nb_ppvth_rt=-0.153 mdn_nb_npvth_up=0.331 mdn_nb_npvth_dn=0.210
+mdn_no_ppvth_lt=-0.461 mdn_no_ppvth_rt=-0.264 mdn_no_npvth_up=0.503 mdn_no_npvth_dn=0.445
**

** 25 PUF stage
xi24 gnd net48 net49 ch_24 net50 net51 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.352 mup_inv_npvth=0.412
+mup_na_ppvth_lt=-0.990 mup_na_ppvth_rt=-0.078 mup_na_npvth_up=0.030 mup_na_npvth_dn=0.207
+mup_nb_ppvth_lt=-0.784 mup_nb_ppvth_rt=-0.556 mup_nb_npvth_up=0.104 mup_nb_npvth_dn=0.386
+mup_no_ppvth_lt=-1.094 mup_no_ppvth_rt=-0.215 mup_no_npvth_up=0.080 mup_no_npvth_dn=0.005

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.305 mdn_inv_npvth=0.501
+mdn_na_ppvth_lt=-0.304 mdn_na_ppvth_rt=-0.108 mdn_na_npvth_up=0.229 mdn_na_npvth_dn=0.477
+mdn_nb_ppvth_lt=-0.572 mdn_nb_ppvth_rt=-0.885 mdn_nb_npvth_up=0.315 mdn_nb_npvth_dn=0.628
+mdn_no_ppvth_lt=-0.304 mdn_no_ppvth_rt=-0.096 mdn_no_npvth_up=0.432 mdn_no_npvth_dn=0.012
**

** 26 PUF stage
xi25 gnd net50 net51 ch_25 net52 net53 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.754 mup_inv_npvth=0.289
+mup_na_ppvth_lt=-0.180 mup_na_ppvth_rt=-0.832 mup_na_npvth_up=0.154 mup_na_npvth_dn=0.455
+mup_nb_ppvth_lt=-0.255 mup_nb_ppvth_rt=-0.365 mup_nb_npvth_up=0.307 mup_nb_npvth_dn=0.532
+mup_no_ppvth_lt=-0.228 mup_no_ppvth_rt=-0.917 mup_no_npvth_up=0.279 mup_no_npvth_dn=0.173

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.026 mdn_inv_npvth=0.835
+mdn_na_ppvth_lt=-0.352 mdn_na_ppvth_rt=-0.423 mdn_na_npvth_up=0.448 mdn_na_npvth_dn=0.002
+mdn_nb_ppvth_lt=-0.582 mdn_nb_ppvth_rt=-0.298 mdn_nb_npvth_up=0.233 mdn_nb_npvth_dn=0.071
+mdn_no_ppvth_lt=-0.257 mdn_no_ppvth_rt=-0.738 mdn_no_npvth_up=0.292 mdn_no_npvth_dn=0.136
**

** 27 PUF stage
xi26 gnd net52 net53 ch_26 net54 net55 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.658 mup_inv_npvth=0.026
+mup_na_ppvth_lt=-0.522 mup_na_ppvth_rt=-0.012 mup_na_npvth_up=0.167 mup_na_npvth_dn=0.269
+mup_nb_ppvth_lt=-0.279 mup_nb_ppvth_rt=-0.130 mup_nb_npvth_up=0.531 mup_nb_npvth_dn=0.318
+mup_no_ppvth_lt=-0.069 mup_no_ppvth_rt=-0.102 mup_no_npvth_up=0.408 mup_no_npvth_dn=0.086

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.010 mdn_inv_npvth=0.292
+mdn_na_ppvth_lt=-0.411 mdn_na_ppvth_rt=-0.559 mdn_na_npvth_up=0.164 mdn_na_npvth_dn=0.726
+mdn_nb_ppvth_lt=-0.023 mdn_nb_ppvth_rt=-0.535 mdn_nb_npvth_up=0.273 mdn_nb_npvth_dn=0.469
+mdn_no_ppvth_lt=-0.192 mdn_no_ppvth_rt=-0.259 mdn_no_npvth_up=0.234 mdn_no_npvth_dn=0.030
**

** 28 PUF stage
xi27 gnd net54 net55 ch_27 net56 net57 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.216 mup_inv_npvth=0.970
+mup_na_ppvth_lt=-0.218 mup_na_ppvth_rt=-0.229 mup_na_npvth_up=0.006 mup_na_npvth_dn=0.041
+mup_nb_ppvth_lt=-0.675 mup_nb_ppvth_rt=-0.163 mup_nb_npvth_up=0.006 mup_nb_npvth_dn=0.318
+mup_no_ppvth_lt=-0.575 mup_no_ppvth_rt=-0.118 mup_no_npvth_up=0.310 mup_no_npvth_dn=0.393

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.850 mdn_inv_npvth=0.719
+mdn_na_ppvth_lt=-0.854 mdn_na_ppvth_rt=-0.077 mdn_na_npvth_up=0.031 mdn_na_npvth_dn=0.222
+mdn_nb_ppvth_lt=-0.498 mdn_nb_ppvth_rt=-0.907 mdn_nb_npvth_up=0.501 mdn_nb_npvth_dn=0.411
+mdn_no_ppvth_lt=-0.383 mdn_no_ppvth_rt=-0.193 mdn_no_npvth_up=0.123 mdn_no_npvth_dn=0.521
**

** 29 PUF stage
xi28 gnd net56 net57 ch_28 net58 net59 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.075 mup_inv_npvth=0.330
+mup_na_ppvth_lt=-0.172 mup_na_ppvth_rt=-0.671 mup_na_npvth_up=0.244 mup_na_npvth_dn=0.346
+mup_nb_ppvth_lt=-0.815 mup_nb_ppvth_rt=-0.526 mup_nb_npvth_up=0.183 mup_nb_npvth_dn=0.021
+mup_no_ppvth_lt=-0.011 mup_no_ppvth_rt=-0.448 mup_no_npvth_up=0.530 mup_no_npvth_dn=0.476

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.637 mdn_inv_npvth=0.302
+mdn_na_ppvth_lt=-0.200 mdn_na_ppvth_rt=-0.260 mdn_na_npvth_up=0.539 mdn_na_npvth_dn=0.172
+mdn_nb_ppvth_lt=-0.203 mdn_nb_ppvth_rt=-0.504 mdn_nb_npvth_up=0.942 mdn_nb_npvth_dn=0.174
+mdn_no_ppvth_lt=-0.160 mdn_no_ppvth_rt=-0.870 mdn_no_npvth_up=0.162 mdn_no_npvth_dn=0.493
**

** 30 PUF stage
xi29 gnd net58 net59 ch_29 net60 net61 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.528 mup_inv_npvth=0.862
+mup_na_ppvth_lt=-0.543 mup_na_ppvth_rt=-0.165 mup_na_npvth_up=0.053 mup_na_npvth_dn=0.693
+mup_nb_ppvth_lt=-0.379 mup_nb_ppvth_rt=-0.807 mup_nb_npvth_up=0.211 mup_nb_npvth_dn=0.079
+mup_no_ppvth_lt=-0.033 mup_no_ppvth_rt=-0.538 mup_no_npvth_up=0.333 mup_no_npvth_dn=0.235

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.764 mdn_inv_npvth=0.023
+mdn_na_ppvth_lt=-0.261 mdn_na_ppvth_rt=-0.357 mdn_na_npvth_up=0.153 mdn_na_npvth_dn=0.734
+mdn_nb_ppvth_lt=-0.891 mdn_nb_ppvth_rt=-0.816 mdn_nb_npvth_up=0.420 mdn_nb_npvth_dn=0.480
+mdn_no_ppvth_lt=-0.150 mdn_no_ppvth_rt=-0.334 mdn_no_npvth_up=0.434 mdn_no_npvth_dn=0.810
**

** 31 PUF stage
xi30 gnd net60 net61 ch_30 net62 net63 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.361 mup_inv_npvth=0.230
+mup_na_ppvth_lt=-0.101 mup_na_ppvth_rt=-0.216 mup_na_npvth_up=0.811 mup_na_npvth_dn=1.085
+mup_nb_ppvth_lt=-0.013 mup_nb_ppvth_rt=-0.646 mup_nb_npvth_up=0.731 mup_nb_npvth_dn=0.136
+mup_no_ppvth_lt=-0.414 mup_no_ppvth_rt=-0.391 mup_no_npvth_up=0.252 mup_no_npvth_dn=0.543

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.147 mdn_inv_npvth=0.121
+mdn_na_ppvth_lt=-0.215 mdn_na_ppvth_rt=-0.412 mdn_na_npvth_up=0.180 mdn_na_npvth_dn=0.341
+mdn_nb_ppvth_lt=-0.164 mdn_nb_ppvth_rt=-0.007 mdn_nb_npvth_up=0.838 mdn_nb_npvth_dn=0.343
+mdn_no_ppvth_lt=-0.430 mdn_no_ppvth_rt=-0.928 mdn_no_npvth_up=0.263 mdn_no_npvth_dn=0.077
**

** 32 PUF stage
xi31 gnd net62 net63 ch_31 net64 net65 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.964 mup_inv_npvth=0.465
+mup_na_ppvth_lt=-0.513 mup_na_ppvth_rt=-0.050 mup_na_npvth_up=0.309 mup_na_npvth_dn=0.238
+mup_nb_ppvth_lt=-0.352 mup_nb_ppvth_rt=-0.951 mup_nb_npvth_up=0.116 mup_nb_npvth_dn=0.280
+mup_no_ppvth_lt=-0.465 mup_no_ppvth_rt=-0.025 mup_no_npvth_up=0.470 mup_no_npvth_dn=0.475

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.440 mdn_inv_npvth=0.504
+mdn_na_ppvth_lt=-0.171 mdn_na_ppvth_rt=-0.126 mdn_na_npvth_up=0.483 mdn_na_npvth_dn=0.420
+mdn_nb_ppvth_lt=-0.403 mdn_nb_ppvth_rt=-0.486 mdn_nb_npvth_up=0.380 mdn_nb_npvth_dn=0.320
+mdn_no_ppvth_lt=-0.692 mdn_no_ppvth_rt=-0.115 mdn_no_npvth_up=0.734 mdn_no_npvth_dn=0.058
**

** 33 PUF stage
xi32 gnd net64 net65 ch_32 net66 net67 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.211 mup_inv_npvth=0.007
+mup_na_ppvth_lt=-0.400 mup_na_ppvth_rt=-0.511 mup_na_npvth_up=0.127 mup_na_npvth_dn=0.218
+mup_nb_ppvth_lt=-0.107 mup_nb_ppvth_rt=-0.243 mup_nb_npvth_up=0.338 mup_nb_npvth_dn=1.189
+mup_no_ppvth_lt=-0.386 mup_no_ppvth_rt=-0.582 mup_no_npvth_up=0.572 mup_no_npvth_dn=0.618

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.431 mdn_inv_npvth=0.514
+mdn_na_ppvth_lt=-0.519 mdn_na_ppvth_rt=-0.177 mdn_na_npvth_up=0.551 mdn_na_npvth_dn=0.246
+mdn_nb_ppvth_lt=-0.269 mdn_nb_ppvth_rt=-0.447 mdn_nb_npvth_up=0.181 mdn_nb_npvth_dn=0.421
+mdn_no_ppvth_lt=-0.360 mdn_no_ppvth_rt=-0.483 mdn_no_npvth_up=0.304 mdn_no_npvth_dn=0.458
**

** 34 PUF stage
xi33 gnd net66 net67 ch_33 net68 net69 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.458 mup_inv_npvth=0.377
+mup_na_ppvth_lt=-0.792 mup_na_ppvth_rt=-0.045 mup_na_npvth_up=0.597 mup_na_npvth_dn=0.101
+mup_nb_ppvth_lt=-0.315 mup_nb_ppvth_rt=-0.264 mup_nb_npvth_up=0.135 mup_nb_npvth_dn=0.559
+mup_no_ppvth_lt=-0.896 mup_no_ppvth_rt=-0.350 mup_no_npvth_up=0.615 mup_no_npvth_dn=0.720

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.300 mdn_inv_npvth=0.012
+mdn_na_ppvth_lt=-0.165 mdn_na_ppvth_rt=-0.315 mdn_na_npvth_up=0.423 mdn_na_npvth_dn=0.246
+mdn_nb_ppvth_lt=-0.573 mdn_nb_ppvth_rt=-0.347 mdn_nb_npvth_up=0.424 mdn_nb_npvth_dn=0.309
+mdn_no_ppvth_lt=-0.250 mdn_no_ppvth_rt=-0.263 mdn_no_npvth_up=0.906 mdn_no_npvth_dn=0.185
**

** 35 PUF stage
xi34 gnd net68 net69 ch_34 net70 net71 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.481 mup_inv_npvth=0.218
+mup_na_ppvth_lt=-0.592 mup_na_ppvth_rt=-0.038 mup_na_npvth_up=0.137 mup_na_npvth_dn=0.213
+mup_nb_ppvth_lt=-0.189 mup_nb_ppvth_rt=-0.156 mup_nb_npvth_up=0.422 mup_nb_npvth_dn=0.522
+mup_no_ppvth_lt=-0.376 mup_no_ppvth_rt=-0.250 mup_no_npvth_up=0.335 mup_no_npvth_dn=0.673

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.034 mdn_inv_npvth=0.118
+mdn_na_ppvth_lt=-0.502 mdn_na_ppvth_rt=-0.033 mdn_na_npvth_up=0.116 mdn_na_npvth_dn=0.257
+mdn_nb_ppvth_lt=-0.300 mdn_nb_ppvth_rt=-0.323 mdn_nb_npvth_up=0.127 mdn_nb_npvth_dn=0.288
+mdn_no_ppvth_lt=-0.666 mdn_no_ppvth_rt=-0.256 mdn_no_npvth_up=0.219 mdn_no_npvth_dn=0.398
**

** 36 PUF stage
xi35 gnd net70 net71 ch_35 net72 net73 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.282 mup_inv_npvth=0.458
+mup_na_ppvth_lt=-0.883 mup_na_ppvth_rt=-0.016 mup_na_npvth_up=0.380 mup_na_npvth_dn=0.076
+mup_nb_ppvth_lt=-0.045 mup_nb_ppvth_rt=-0.916 mup_nb_npvth_up=0.290 mup_nb_npvth_dn=0.185
+mup_no_ppvth_lt=-0.036 mup_no_ppvth_rt=-0.261 mup_no_npvth_up=0.558 mup_no_npvth_dn=0.211

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.046 mdn_inv_npvth=0.189
+mdn_na_ppvth_lt=-0.039 mdn_na_ppvth_rt=-0.181 mdn_na_npvth_up=0.279 mdn_na_npvth_dn=0.564
+mdn_nb_ppvth_lt=-0.261 mdn_nb_ppvth_rt=-0.562 mdn_nb_npvth_up=0.222 mdn_nb_npvth_dn=0.411
+mdn_no_ppvth_lt=-0.621 mdn_no_ppvth_rt=-0.166 mdn_no_npvth_up=0.294 mdn_no_npvth_dn=0.877
**

** 37 PUF stage
xi36 gnd net72 net73 ch_36 net74 net75 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.040 mup_inv_npvth=0.075
+mup_na_ppvth_lt=-0.383 mup_na_ppvth_rt=-0.644 mup_na_npvth_up=0.316 mup_na_npvth_dn=0.015
+mup_nb_ppvth_lt=-0.163 mup_nb_ppvth_rt=-0.506 mup_nb_npvth_up=0.066 mup_nb_npvth_dn=0.188
+mup_no_ppvth_lt=-0.755 mup_no_ppvth_rt=-0.461 mup_no_npvth_up=0.737 mup_no_npvth_dn=0.151

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.289 mdn_inv_npvth=0.328
+mdn_na_ppvth_lt=-0.257 mdn_na_ppvth_rt=-0.052 mdn_na_npvth_up=0.112 mdn_na_npvth_dn=0.539
+mdn_nb_ppvth_lt=-0.232 mdn_nb_ppvth_rt=-0.262 mdn_nb_npvth_up=0.004 mdn_nb_npvth_dn=0.212
+mdn_no_ppvth_lt=-0.502 mdn_no_ppvth_rt=-0.082 mdn_no_npvth_up=0.437 mdn_no_npvth_dn=0.338
**

** 38 PUF stage
xi37 gnd net74 net75 ch_37 net76 net77 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.170 mup_inv_npvth=0.420
+mup_na_ppvth_lt=-0.644 mup_na_ppvth_rt=-0.355 mup_na_npvth_up=0.304 mup_na_npvth_dn=0.437
+mup_nb_ppvth_lt=-0.137 mup_nb_ppvth_rt=-0.462 mup_nb_npvth_up=0.174 mup_nb_npvth_dn=0.465
+mup_no_ppvth_lt=-0.103 mup_no_ppvth_rt=-0.532 mup_no_npvth_up=0.574 mup_no_npvth_dn=0.652

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.581 mdn_inv_npvth=0.439
+mdn_na_ppvth_lt=-0.426 mdn_na_ppvth_rt=-0.159 mdn_na_npvth_up=0.289 mdn_na_npvth_dn=0.411
+mdn_nb_ppvth_lt=-0.572 mdn_nb_ppvth_rt=-0.611 mdn_nb_npvth_up=0.456 mdn_nb_npvth_dn=0.193
+mdn_no_ppvth_lt=-0.088 mdn_no_ppvth_rt=-0.049 mdn_no_npvth_up=0.472 mdn_no_npvth_dn=0.622
**

** 39 PUF stage
xi38 gnd net76 net77 ch_38 net78 net79 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.027 mup_inv_npvth=0.376
+mup_na_ppvth_lt=-0.152 mup_na_ppvth_rt=-0.159 mup_na_npvth_up=0.258 mup_na_npvth_dn=0.126
+mup_nb_ppvth_lt=-0.987 mup_nb_ppvth_rt=-0.420 mup_nb_npvth_up=0.224 mup_nb_npvth_dn=0.518
+mup_no_ppvth_lt=-0.058 mup_no_ppvth_rt=-0.133 mup_no_npvth_up=0.482 mup_no_npvth_dn=0.032

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.126 mdn_inv_npvth=0.070
+mdn_na_ppvth_lt=-0.895 mdn_na_ppvth_rt=-0.233 mdn_na_npvth_up=0.344 mdn_na_npvth_dn=0.074
+mdn_nb_ppvth_lt=-0.490 mdn_nb_ppvth_rt=-0.014 mdn_nb_npvth_up=0.448 mdn_nb_npvth_dn=0.043
+mdn_no_ppvth_lt=-0.524 mdn_no_ppvth_rt=-0.567 mdn_no_npvth_up=0.692 mdn_no_npvth_dn=0.156
**

** 40 PUF stage
xi39 gnd net78 net79 ch_39 net80 net81 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.157 mup_inv_npvth=0.467
+mup_na_ppvth_lt=-0.213 mup_na_ppvth_rt=-0.738 mup_na_npvth_up=0.473 mup_na_npvth_dn=0.143
+mup_nb_ppvth_lt=-0.645 mup_nb_ppvth_rt=-0.409 mup_nb_npvth_up=0.463 mup_nb_npvth_dn=0.150
+mup_no_ppvth_lt=-0.615 mup_no_ppvth_rt=-0.322 mup_no_npvth_up=0.016 mup_no_npvth_dn=0.474

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.039 mdn_inv_npvth=0.522
+mdn_na_ppvth_lt=-0.416 mdn_na_ppvth_rt=-0.452 mdn_na_npvth_up=0.502 mdn_na_npvth_dn=0.410
+mdn_nb_ppvth_lt=-0.493 mdn_nb_ppvth_rt=-0.033 mdn_nb_npvth_up=0.252 mdn_nb_npvth_dn=0.807
+mdn_no_ppvth_lt=-0.972 mdn_no_ppvth_rt=-0.108 mdn_no_npvth_up=0.426 mdn_no_npvth_dn=0.081
**

** 41 PUF stage
xi40 gnd net80 net81 ch_40 net82 net83 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.176 mup_inv_npvth=0.365
+mup_na_ppvth_lt=-0.405 mup_na_ppvth_rt=-0.021 mup_na_npvth_up=0.269 mup_na_npvth_dn=0.200
+mup_nb_ppvth_lt=-0.644 mup_nb_ppvth_rt=-0.702 mup_nb_npvth_up=0.300 mup_nb_npvth_dn=0.095
+mup_no_ppvth_lt=-0.270 mup_no_ppvth_rt=-0.808 mup_no_npvth_up=0.660 mup_no_npvth_dn=0.169

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.636 mdn_inv_npvth=0.526
+mdn_na_ppvth_lt=-0.251 mdn_na_ppvth_rt=-0.227 mdn_na_npvth_up=0.176 mdn_na_npvth_dn=0.286
+mdn_nb_ppvth_lt=-0.794 mdn_nb_ppvth_rt=-0.229 mdn_nb_npvth_up=0.430 mdn_nb_npvth_dn=0.168
+mdn_no_ppvth_lt=-0.281 mdn_no_ppvth_rt=-0.281 mdn_no_npvth_up=0.053 mdn_no_npvth_dn=0.520
**

** 42 PUF stage
xi41 gnd net82 net83 ch_41 net84 net85 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.385 mup_inv_npvth=0.270
+mup_na_ppvth_lt=-0.147 mup_na_ppvth_rt=-0.846 mup_na_npvth_up=0.537 mup_na_npvth_dn=0.131
+mup_nb_ppvth_lt=-0.010 mup_nb_ppvth_rt=-0.125 mup_nb_npvth_up=0.460 mup_nb_npvth_dn=0.519
+mup_no_ppvth_lt=-0.324 mup_no_ppvth_rt=-0.342 mup_no_npvth_up=0.141 mup_no_npvth_dn=0.181

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.379 mdn_inv_npvth=0.281
+mdn_na_ppvth_lt=-0.840 mdn_na_ppvth_rt=-0.366 mdn_na_npvth_up=0.521 mdn_na_npvth_dn=0.392
+mdn_nb_ppvth_lt=-0.843 mdn_nb_ppvth_rt=-1.325 mdn_nb_npvth_up=0.058 mdn_nb_npvth_dn=0.587
+mdn_no_ppvth_lt=-0.594 mdn_no_ppvth_rt=-0.582 mdn_no_npvth_up=0.670 mdn_no_npvth_dn=1.070
**

** 43 PUF stage
xi42 gnd net84 net85 ch_42 net86 net87 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.559 mup_inv_npvth=0.102
+mup_na_ppvth_lt=-0.002 mup_na_ppvth_rt=-0.259 mup_na_npvth_up=0.065 mup_na_npvth_dn=0.063
+mup_nb_ppvth_lt=-0.108 mup_nb_ppvth_rt=-0.714 mup_nb_npvth_up=0.966 mup_nb_npvth_dn=0.294
+mup_no_ppvth_lt=-0.036 mup_no_ppvth_rt=-0.260 mup_no_npvth_up=0.523 mup_no_npvth_dn=0.139

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.236 mdn_inv_npvth=0.372
+mdn_na_ppvth_lt=-0.269 mdn_na_ppvth_rt=-0.227 mdn_na_npvth_up=0.023 mdn_na_npvth_dn=0.491
+mdn_nb_ppvth_lt=-0.695 mdn_nb_ppvth_rt=-0.157 mdn_nb_npvth_up=0.659 mdn_nb_npvth_dn=0.320
+mdn_no_ppvth_lt=-0.401 mdn_no_ppvth_rt=-0.232 mdn_no_npvth_up=0.442 mdn_no_npvth_dn=0.140
**

** 44 PUF stage
xi43 gnd net86 net87 ch_43 net88 net89 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-1.190 mup_inv_npvth=0.440
+mup_na_ppvth_lt=-0.735 mup_na_ppvth_rt=-0.640 mup_na_npvth_up=0.111 mup_na_npvth_dn=0.212
+mup_nb_ppvth_lt=-0.671 mup_nb_ppvth_rt=-0.079 mup_nb_npvth_up=0.053 mup_nb_npvth_dn=0.458
+mup_no_ppvth_lt=-0.666 mup_no_ppvth_rt=-0.180 mup_no_npvth_up=0.397 mup_no_npvth_dn=0.219

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.230 mdn_inv_npvth=0.262
+mdn_na_ppvth_lt=-0.380 mdn_na_ppvth_rt=-0.059 mdn_na_npvth_up=0.105 mdn_na_npvth_dn=0.276
+mdn_nb_ppvth_lt=-0.624 mdn_nb_ppvth_rt=-0.428 mdn_nb_npvth_up=0.393 mdn_nb_npvth_dn=0.265
+mdn_no_ppvth_lt=-0.001 mdn_no_ppvth_rt=-0.237 mdn_no_npvth_up=0.458 mdn_no_npvth_dn=0.326
**

** 45 PUF stage
xi44 gnd net88 net89 ch_44 net90 net91 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.699 mup_inv_npvth=0.356
+mup_na_ppvth_lt=-0.295 mup_na_ppvth_rt=-0.294 mup_na_npvth_up=0.124 mup_na_npvth_dn=0.714
+mup_nb_ppvth_lt=-0.082 mup_nb_ppvth_rt=-0.014 mup_nb_npvth_up=0.726 mup_nb_npvth_dn=0.281
+mup_no_ppvth_lt=-0.035 mup_no_ppvth_rt=-0.767 mup_no_npvth_up=0.388 mup_no_npvth_dn=0.257

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.305 mdn_inv_npvth=0.126
+mdn_na_ppvth_lt=-0.647 mdn_na_ppvth_rt=-0.181 mdn_na_npvth_up=0.144 mdn_na_npvth_dn=0.798
+mdn_nb_ppvth_lt=-0.662 mdn_nb_ppvth_rt=-0.215 mdn_nb_npvth_up=0.123 mdn_nb_npvth_dn=0.418
+mdn_no_ppvth_lt=-0.065 mdn_no_ppvth_rt=-0.143 mdn_no_npvth_up=0.255 mdn_no_npvth_dn=0.435
**

** 46 PUF stage
xi45 gnd net90 net91 ch_45 net92 net93 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.004 mup_inv_npvth=0.404
+mup_na_ppvth_lt=-0.402 mup_na_ppvth_rt=-0.012 mup_na_npvth_up=0.806 mup_na_npvth_dn=0.209
+mup_nb_ppvth_lt=-0.484 mup_nb_ppvth_rt=-0.007 mup_nb_npvth_up=0.408 mup_nb_npvth_dn=0.547
+mup_no_ppvth_lt=-0.442 mup_no_ppvth_rt=-1.046 mup_no_npvth_up=0.430 mup_no_npvth_dn=0.171

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.194 mdn_inv_npvth=0.288
+mdn_na_ppvth_lt=-0.797 mdn_na_ppvth_rt=-0.160 mdn_na_npvth_up=0.391 mdn_na_npvth_dn=0.231
+mdn_nb_ppvth_lt=-0.124 mdn_nb_ppvth_rt=-0.597 mdn_nb_npvth_up=0.350 mdn_nb_npvth_dn=0.700
+mdn_no_ppvth_lt=-0.027 mdn_no_ppvth_rt=-0.115 mdn_no_npvth_up=0.813 mdn_no_npvth_dn=0.186
**

** 47 PUF stage
xi46 gnd net92 net93 ch_46 net94 net95 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.336 mup_inv_npvth=0.058
+mup_na_ppvth_lt=-0.018 mup_na_ppvth_rt=-0.317 mup_na_npvth_up=0.336 mup_na_npvth_dn=0.497
+mup_nb_ppvth_lt=-0.258 mup_nb_ppvth_rt=-1.069 mup_nb_npvth_up=0.125 mup_nb_npvth_dn=0.476
+mup_no_ppvth_lt=-0.619 mup_no_ppvth_rt=-0.117 mup_no_npvth_up=0.292 mup_no_npvth_dn=0.612

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.832 mdn_inv_npvth=0.886
+mdn_na_ppvth_lt=-0.070 mdn_na_ppvth_rt=-0.646 mdn_na_npvth_up=0.445 mdn_na_npvth_dn=0.003
+mdn_nb_ppvth_lt=-0.035 mdn_nb_ppvth_rt=-0.075 mdn_nb_npvth_up=0.327 mdn_nb_npvth_dn=0.179
+mdn_no_ppvth_lt=-0.064 mdn_no_ppvth_rt=-0.266 mdn_no_npvth_up=0.905 mdn_no_npvth_dn=0.059
**

** 48 PUF stage
xi47 gnd net94 net95 ch_47 net96 net97 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.184 mup_inv_npvth=0.628
+mup_na_ppvth_lt=-0.338 mup_na_ppvth_rt=-0.253 mup_na_npvth_up=0.076 mup_na_npvth_dn=0.293
+mup_nb_ppvth_lt=-0.265 mup_nb_ppvth_rt=-0.100 mup_nb_npvth_up=0.825 mup_nb_npvth_dn=1.440
+mup_no_ppvth_lt=-0.564 mup_no_ppvth_rt=-0.045 mup_no_npvth_up=0.727 mup_no_npvth_dn=0.499

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.163 mdn_inv_npvth=0.095
+mdn_na_ppvth_lt=-0.011 mdn_na_ppvth_rt=-0.952 mdn_na_npvth_up=0.717 mdn_na_npvth_dn=0.165
+mdn_nb_ppvth_lt=-0.362 mdn_nb_ppvth_rt=-0.745 mdn_nb_npvth_up=0.117 mdn_nb_npvth_dn=0.253
+mdn_no_ppvth_lt=-0.306 mdn_no_ppvth_rt=-0.089 mdn_no_npvth_up=0.085 mdn_no_npvth_dn=0.153
**

** 49 PUF stage
xi48 gnd net96 net97 ch_48 net98 net99 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.084 mup_inv_npvth=0.150
+mup_na_ppvth_lt=-0.274 mup_na_ppvth_rt=-0.432 mup_na_npvth_up=0.326 mup_na_npvth_dn=0.110
+mup_nb_ppvth_lt=-0.155 mup_nb_ppvth_rt=-0.299 mup_nb_npvth_up=0.312 mup_nb_npvth_dn=0.367
+mup_no_ppvth_lt=-0.423 mup_no_ppvth_rt=-0.056 mup_no_npvth_up=0.070 mup_no_npvth_dn=0.073

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.712 mdn_inv_npvth=0.033
+mdn_na_ppvth_lt=-0.697 mdn_na_ppvth_rt=-0.269 mdn_na_npvth_up=1.049 mdn_na_npvth_dn=0.386
+mdn_nb_ppvth_lt=-0.405 mdn_nb_ppvth_rt=-0.792 mdn_nb_npvth_up=0.761 mdn_nb_npvth_dn=0.435
+mdn_no_ppvth_lt=-0.077 mdn_no_ppvth_rt=-0.522 mdn_no_npvth_up=0.532 mdn_no_npvth_dn=0.054
**

** 50 PUF stage
xi49 gnd net98 net99 ch_49 net100 net101 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.275 mup_inv_npvth=0.439
+mup_na_ppvth_lt=-0.400 mup_na_ppvth_rt=-0.351 mup_na_npvth_up=0.499 mup_na_npvth_dn=0.662
+mup_nb_ppvth_lt=-0.294 mup_nb_ppvth_rt=-0.585 mup_nb_npvth_up=0.118 mup_nb_npvth_dn=0.041
+mup_no_ppvth_lt=-0.017 mup_no_ppvth_rt=-0.409 mup_no_npvth_up=0.361 mup_no_npvth_dn=0.290

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.597 mdn_inv_npvth=0.767
+mdn_na_ppvth_lt=-0.093 mdn_na_ppvth_rt=-0.269 mdn_na_npvth_up=0.040 mdn_na_npvth_dn=0.188
+mdn_nb_ppvth_lt=-0.097 mdn_nb_ppvth_rt=-0.069 mdn_nb_npvth_up=0.045 mdn_nb_npvth_dn=0.055
+mdn_no_ppvth_lt=-0.969 mdn_no_ppvth_rt=-0.396 mdn_no_npvth_up=0.355 mdn_no_npvth_dn=0.438
**

** 51 PUF stage
xi50 gnd net100 net101 ch_50 net102 net103 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.209 mup_inv_npvth=0.119
+mup_na_ppvth_lt=-0.783 mup_na_ppvth_rt=-1.168 mup_na_npvth_up=0.338 mup_na_npvth_dn=0.404
+mup_nb_ppvth_lt=-0.545 mup_nb_ppvth_rt=-0.954 mup_nb_npvth_up=0.667 mup_nb_npvth_dn=0.288
+mup_no_ppvth_lt=-0.342 mup_no_ppvth_rt=-0.187 mup_no_npvth_up=0.567 mup_no_npvth_dn=0.086

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.141 mdn_inv_npvth=0.269
+mdn_na_ppvth_lt=-0.047 mdn_na_ppvth_rt=-0.457 mdn_na_npvth_up=0.303 mdn_na_npvth_dn=0.111
+mdn_nb_ppvth_lt=-0.495 mdn_nb_ppvth_rt=-0.256 mdn_nb_npvth_up=0.138 mdn_nb_npvth_dn=0.215
+mdn_no_ppvth_lt=-0.074 mdn_no_ppvth_rt=-0.275 mdn_no_npvth_up=0.446 mdn_no_npvth_dn=0.389
**

** 52 PUF stage
xi51 gnd net102 net103 ch_51 net104 net105 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.403 mup_inv_npvth=0.141
+mup_na_ppvth_lt=-0.388 mup_na_ppvth_rt=-0.641 mup_na_npvth_up=0.626 mup_na_npvth_dn=0.465
+mup_nb_ppvth_lt=-0.012 mup_nb_ppvth_rt=-0.372 mup_nb_npvth_up=0.089 mup_nb_npvth_dn=0.717
+mup_no_ppvth_lt=-0.726 mup_no_ppvth_rt=-0.067 mup_no_npvth_up=0.290 mup_no_npvth_dn=0.259

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.374 mdn_inv_npvth=0.183
+mdn_na_ppvth_lt=-0.051 mdn_na_ppvth_rt=-0.744 mdn_na_npvth_up=0.762 mdn_na_npvth_dn=0.300
+mdn_nb_ppvth_lt=-0.021 mdn_nb_ppvth_rt=-1.137 mdn_nb_npvth_up=0.094 mdn_nb_npvth_dn=0.373
+mdn_no_ppvth_lt=-0.204 mdn_no_ppvth_rt=-0.565 mdn_no_npvth_up=0.185 mdn_no_npvth_dn=0.113
**

** 53 PUF stage
xi52 gnd net104 net105 ch_52 net106 net107 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.615 mup_inv_npvth=0.230
+mup_na_ppvth_lt=-0.885 mup_na_ppvth_rt=-0.928 mup_na_npvth_up=0.855 mup_na_npvth_dn=0.576
+mup_nb_ppvth_lt=-0.323 mup_nb_ppvth_rt=-0.070 mup_nb_npvth_up=0.459 mup_nb_npvth_dn=0.354
+mup_no_ppvth_lt=-0.014 mup_no_ppvth_rt=-0.675 mup_no_npvth_up=0.085 mup_no_npvth_dn=0.683

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.416 mdn_inv_npvth=0.213
+mdn_na_ppvth_lt=-0.612 mdn_na_ppvth_rt=-0.435 mdn_na_npvth_up=0.389 mdn_na_npvth_dn=0.015
+mdn_nb_ppvth_lt=-0.016 mdn_nb_ppvth_rt=-0.396 mdn_nb_npvth_up=0.344 mdn_nb_npvth_dn=0.003
+mdn_no_ppvth_lt=-0.044 mdn_no_ppvth_rt=-0.254 mdn_no_npvth_up=0.589 mdn_no_npvth_dn=0.348
**

** 54 PUF stage
xi53 gnd net106 net107 ch_53 net108 net109 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.054 mup_inv_npvth=0.525
+mup_na_ppvth_lt=-0.282 mup_na_ppvth_rt=-1.022 mup_na_npvth_up=0.441 mup_na_npvth_dn=0.136
+mup_nb_ppvth_lt=-0.344 mup_nb_ppvth_rt=-0.125 mup_nb_npvth_up=0.326 mup_nb_npvth_dn=0.565
+mup_no_ppvth_lt=-0.658 mup_no_ppvth_rt=-0.123 mup_no_npvth_up=0.778 mup_no_npvth_dn=0.606

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.054 mdn_inv_npvth=0.200
+mdn_na_ppvth_lt=-0.079 mdn_na_ppvth_rt=-0.080 mdn_na_npvth_up=0.290 mdn_na_npvth_dn=0.101
+mdn_nb_ppvth_lt=-0.884 mdn_nb_ppvth_rt=-0.483 mdn_nb_npvth_up=0.262 mdn_nb_npvth_dn=0.595
+mdn_no_ppvth_lt=-0.585 mdn_no_ppvth_rt=-0.349 mdn_no_npvth_up=0.517 mdn_no_npvth_dn=0.313
**

** 55 PUF stage
xi54 gnd net108 net109 ch_54 net110 net111 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.162 mup_inv_npvth=0.123
+mup_na_ppvth_lt=-0.336 mup_na_ppvth_rt=-0.228 mup_na_npvth_up=0.597 mup_na_npvth_dn=0.368
+mup_nb_ppvth_lt=-0.185 mup_nb_ppvth_rt=-0.048 mup_nb_npvth_up=0.185 mup_nb_npvth_dn=0.528
+mup_no_ppvth_lt=-0.016 mup_no_ppvth_rt=-0.761 mup_no_npvth_up=0.702 mup_no_npvth_dn=0.201

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.769 mdn_inv_npvth=0.965
+mdn_na_ppvth_lt=-0.131 mdn_na_ppvth_rt=-1.192 mdn_na_npvth_up=0.640 mdn_na_npvth_dn=0.269
+mdn_nb_ppvth_lt=-0.339 mdn_nb_ppvth_rt=-0.102 mdn_nb_npvth_up=0.702 mdn_nb_npvth_dn=0.156
+mdn_no_ppvth_lt=-0.765 mdn_no_ppvth_rt=-0.549 mdn_no_npvth_up=0.643 mdn_no_npvth_dn=0.316
**

** 56 PUF stage
xi55 gnd net110 net111 ch_55 net112 net113 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.002 mup_inv_npvth=0.178
+mup_na_ppvth_lt=-0.116 mup_na_ppvth_rt=-0.393 mup_na_npvth_up=0.131 mup_na_npvth_dn=0.376
+mup_nb_ppvth_lt=-0.735 mup_nb_ppvth_rt=-0.936 mup_nb_npvth_up=0.547 mup_nb_npvth_dn=0.168
+mup_no_ppvth_lt=-0.336 mup_no_ppvth_rt=-0.438 mup_no_npvth_up=0.183 mup_no_npvth_dn=0.031

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.032 mdn_inv_npvth=0.858
+mdn_na_ppvth_lt=-0.209 mdn_na_ppvth_rt=-0.324 mdn_na_npvth_up=0.607 mdn_na_npvth_dn=0.003
+mdn_nb_ppvth_lt=-0.041 mdn_nb_ppvth_rt=-0.148 mdn_nb_npvth_up=0.455 mdn_nb_npvth_dn=0.177
+mdn_no_ppvth_lt=-0.250 mdn_no_ppvth_rt=-0.670 mdn_no_npvth_up=0.229 mdn_no_npvth_dn=0.195
**

** 57 PUF stage
xi56 gnd net112 net113 ch_56 net114 net115 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.577 mup_inv_npvth=0.770
+mup_na_ppvth_lt=-0.412 mup_na_ppvth_rt=-0.250 mup_na_npvth_up=0.402 mup_na_npvth_dn=0.607
+mup_nb_ppvth_lt=-0.418 mup_nb_ppvth_rt=-0.642 mup_nb_npvth_up=0.272 mup_nb_npvth_dn=0.678
+mup_no_ppvth_lt=-0.057 mup_no_ppvth_rt=-1.030 mup_no_npvth_up=0.469 mup_no_npvth_dn=0.195

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.051 mdn_inv_npvth=0.754
+mdn_na_ppvth_lt=-0.843 mdn_na_ppvth_rt=-0.515 mdn_na_npvth_up=0.362 mdn_na_npvth_dn=0.232
+mdn_nb_ppvth_lt=-0.673 mdn_nb_ppvth_rt=-0.431 mdn_nb_npvth_up=0.005 mdn_nb_npvth_dn=0.117
+mdn_no_ppvth_lt=-0.547 mdn_no_ppvth_rt=-0.038 mdn_no_npvth_up=0.467 mdn_no_npvth_dn=0.117
**

** 58 PUF stage
xi57 gnd net114 net115 ch_57 net116 net117 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.136 mup_inv_npvth=0.017
+mup_na_ppvth_lt=-0.149 mup_na_ppvth_rt=-0.220 mup_na_npvth_up=0.219 mup_na_npvth_dn=0.117
+mup_nb_ppvth_lt=-0.400 mup_nb_ppvth_rt=-0.207 mup_nb_npvth_up=0.326 mup_nb_npvth_dn=0.694
+mup_no_ppvth_lt=-0.028 mup_no_ppvth_rt=-0.405 mup_no_npvth_up=0.096 mup_no_npvth_dn=0.158

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.123 mdn_inv_npvth=0.059
+mdn_na_ppvth_lt=-0.017 mdn_na_ppvth_rt=-0.073 mdn_na_npvth_up=0.371 mdn_na_npvth_dn=0.241
+mdn_nb_ppvth_lt=-0.654 mdn_nb_ppvth_rt=-0.260 mdn_nb_npvth_up=0.340 mdn_nb_npvth_dn=0.412
+mdn_no_ppvth_lt=-0.285 mdn_no_ppvth_rt=-0.664 mdn_no_npvth_up=0.004 mdn_no_npvth_dn=0.069
**

** 59 PUF stage
xi58 gnd net116 net117 ch_58 net118 net119 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.510 mup_inv_npvth=0.589
+mup_na_ppvth_lt=-0.440 mup_na_ppvth_rt=-0.606 mup_na_npvth_up=0.537 mup_na_npvth_dn=0.004
+mup_nb_ppvth_lt=-0.094 mup_nb_ppvth_rt=-0.625 mup_nb_npvth_up=0.013 mup_nb_npvth_dn=0.087
+mup_no_ppvth_lt=-0.294 mup_no_ppvth_rt=-0.372 mup_no_npvth_up=0.102 mup_no_npvth_dn=0.263

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.656 mdn_inv_npvth=0.174
+mdn_na_ppvth_lt=-0.096 mdn_na_ppvth_rt=-0.336 mdn_na_npvth_up=0.669 mdn_na_npvth_dn=0.039
+mdn_nb_ppvth_lt=-0.333 mdn_nb_ppvth_rt=-0.517 mdn_nb_npvth_up=0.439 mdn_nb_npvth_dn=0.387
+mdn_no_ppvth_lt=-0.677 mdn_no_ppvth_rt=-0.332 mdn_no_npvth_up=0.274 mdn_no_npvth_dn=0.004
**

** 60 PUF stage
xi59 gnd net118 net119 ch_59 net120 net121 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.170 mup_inv_npvth=0.440
+mup_na_ppvth_lt=-0.269 mup_na_ppvth_rt=-0.283 mup_na_npvth_up=0.781 mup_na_npvth_dn=0.470
+mup_nb_ppvth_lt=-0.251 mup_nb_ppvth_rt=-0.142 mup_nb_npvth_up=0.259 mup_nb_npvth_dn=0.810
+mup_no_ppvth_lt=-0.130 mup_no_ppvth_rt=-0.797 mup_no_npvth_up=0.223 mup_no_npvth_dn=0.167

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.691 mdn_inv_npvth=0.207
+mdn_na_ppvth_lt=-0.240 mdn_na_ppvth_rt=-0.232 mdn_na_npvth_up=0.425 mdn_na_npvth_dn=0.541
+mdn_nb_ppvth_lt=-0.281 mdn_nb_ppvth_rt=-0.953 mdn_nb_npvth_up=0.606 mdn_nb_npvth_dn=0.010
+mdn_no_ppvth_lt=-0.423 mdn_no_ppvth_rt=-0.242 mdn_no_npvth_up=0.227 mdn_no_npvth_dn=0.317
**

** 61 PUF stage
xi60 gnd net120 net121 ch_60 net122 net123 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.226 mup_inv_npvth=0.136
+mup_na_ppvth_lt=-0.250 mup_na_ppvth_rt=-0.703 mup_na_npvth_up=0.340 mup_na_npvth_dn=0.188
+mup_nb_ppvth_lt=-0.437 mup_nb_ppvth_rt=-0.519 mup_nb_npvth_up=0.349 mup_nb_npvth_dn=0.816
+mup_no_ppvth_lt=-0.012 mup_no_ppvth_rt=-0.332 mup_no_npvth_up=0.350 mup_no_npvth_dn=0.620

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.398 mdn_inv_npvth=0.294
+mdn_na_ppvth_lt=-0.030 mdn_na_ppvth_rt=-0.503 mdn_na_npvth_up=0.408 mdn_na_npvth_dn=0.069
+mdn_nb_ppvth_lt=-0.371 mdn_nb_ppvth_rt=-0.501 mdn_nb_npvth_up=0.034 mdn_nb_npvth_dn=0.588
+mdn_no_ppvth_lt=-0.257 mdn_no_ppvth_rt=-0.373 mdn_no_npvth_up=0.122 mdn_no_npvth_dn=0.048
**

** 62 PUF stage
xi61 gnd net122 net123 ch_61 net124 net125 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.159 mup_inv_npvth=0.312
+mup_na_ppvth_lt=-0.611 mup_na_ppvth_rt=-0.132 mup_na_npvth_up=0.666 mup_na_npvth_dn=0.233
+mup_nb_ppvth_lt=-0.887 mup_nb_ppvth_rt=-0.176 mup_nb_npvth_up=0.060 mup_nb_npvth_dn=0.512
+mup_no_ppvth_lt=-0.030 mup_no_ppvth_rt=-0.254 mup_no_npvth_up=0.078 mup_no_npvth_dn=0.259

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.357 mdn_inv_npvth=0.104
+mdn_na_ppvth_lt=-0.668 mdn_na_ppvth_rt=-0.008 mdn_na_npvth_up=0.100 mdn_na_npvth_dn=0.633
+mdn_nb_ppvth_lt=-0.098 mdn_nb_ppvth_rt=-0.262 mdn_nb_npvth_up=0.641 mdn_nb_npvth_dn=0.186
+mdn_no_ppvth_lt=-0.671 mdn_no_ppvth_rt=-0.199 mdn_no_npvth_up=0.595 mdn_no_npvth_dn=0.032
**

** 63 PUF stage
xi62 gnd net124 net125 ch_62 net126 net127 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.745 mup_inv_npvth=0.687
+mup_na_ppvth_lt=-0.055 mup_na_ppvth_rt=-0.240 mup_na_npvth_up=0.544 mup_na_npvth_dn=0.244
+mup_nb_ppvth_lt=-0.848 mup_nb_ppvth_rt=-0.208 mup_nb_npvth_up=0.535 mup_nb_npvth_dn=0.519
+mup_no_ppvth_lt=-0.069 mup_no_ppvth_rt=-0.311 mup_no_npvth_up=0.772 mup_no_npvth_dn=0.540

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.355 mdn_inv_npvth=0.178
+mdn_na_ppvth_lt=-0.755 mdn_na_ppvth_rt=-0.046 mdn_na_npvth_up=0.838 mdn_na_npvth_dn=0.525
+mdn_nb_ppvth_lt=-0.948 mdn_nb_ppvth_rt=-0.225 mdn_nb_npvth_up=0.187 mdn_nb_npvth_dn=0.059
+mdn_no_ppvth_lt=-0.558 mdn_no_ppvth_rt=-0.348 mdn_no_npvth_up=0.963 mdn_no_npvth_dn=0.747
**

** 64 PUF stage
xi63 gnd net126 net127 ch_63 net128 net129 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.654 mup_inv_npvth=0.344
+mup_na_ppvth_lt=-0.289 mup_na_ppvth_rt=-0.226 mup_na_npvth_up=0.368 mup_na_npvth_dn=0.143
+mup_nb_ppvth_lt=-0.338 mup_nb_ppvth_rt=-0.061 mup_nb_npvth_up=0.378 mup_nb_npvth_dn=0.079
+mup_no_ppvth_lt=-0.368 mup_no_ppvth_rt=-0.428 mup_no_npvth_up=0.386 mup_no_npvth_dn=0.697

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.357 mdn_inv_npvth=0.420
+mdn_na_ppvth_lt=-0.068 mdn_na_ppvth_rt=-0.076 mdn_na_npvth_up=0.456 mdn_na_npvth_dn=0.150
+mdn_nb_ppvth_lt=-0.315 mdn_nb_ppvth_rt=-0.551 mdn_nb_npvth_up=0.145 mdn_nb_npvth_dn=0.075
+mdn_no_ppvth_lt=-0.546 mdn_no_ppvth_rt=-0.139 mdn_no_npvth_up=0.615 mdn_no_npvth_dn=0.138
**

** 65 PUF stage
xi64 gnd net128 net129 ch_64 net130 net131 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.453 mup_inv_npvth=0.494
+mup_na_ppvth_lt=-0.598 mup_na_ppvth_rt=-0.104 mup_na_npvth_up=0.477 mup_na_npvth_dn=0.092
+mup_nb_ppvth_lt=-0.143 mup_nb_ppvth_rt=-0.493 mup_nb_npvth_up=0.240 mup_nb_npvth_dn=1.046
+mup_no_ppvth_lt=-0.282 mup_no_ppvth_rt=-0.339 mup_no_npvth_up=0.093 mup_no_npvth_dn=0.647

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.294 mdn_inv_npvth=0.437
+mdn_na_ppvth_lt=-0.579 mdn_na_ppvth_rt=-0.453 mdn_na_npvth_up=0.737 mdn_na_npvth_dn=0.952
+mdn_nb_ppvth_lt=-0.227 mdn_nb_ppvth_rt=-0.146 mdn_nb_npvth_up=0.044 mdn_nb_npvth_dn=0.447
+mdn_no_ppvth_lt=-0.318 mdn_no_ppvth_rt=-0.316 mdn_no_npvth_up=0.092 mdn_no_npvth_dn=0.095
**

** 66 PUF stage
xi65 gnd net130 net131 ch_65 net132 net133 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-1.151 mup_inv_npvth=0.323
+mup_na_ppvth_lt=-0.683 mup_na_ppvth_rt=-0.551 mup_na_npvth_up=0.022 mup_na_npvth_dn=0.721
+mup_nb_ppvth_lt=-0.018 mup_nb_ppvth_rt=-0.145 mup_nb_npvth_up=0.434 mup_nb_npvth_dn=0.306
+mup_no_ppvth_lt=-0.234 mup_no_ppvth_rt=-0.375 mup_no_npvth_up=0.674 mup_no_npvth_dn=0.065

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.436 mdn_inv_npvth=0.572
+mdn_na_ppvth_lt=-0.384 mdn_na_ppvth_rt=-0.353 mdn_na_npvth_up=0.001 mdn_na_npvth_dn=0.102
+mdn_nb_ppvth_lt=-0.306 mdn_nb_ppvth_rt=-0.240 mdn_nb_npvth_up=0.370 mdn_nb_npvth_dn=0.851
+mdn_no_ppvth_lt=-0.051 mdn_no_ppvth_rt=-0.837 mdn_no_npvth_up=0.634 mdn_no_npvth_dn=0.323
**

** 67 PUF stage
xi66 gnd net132 net133 ch_66 net134 net135 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.495 mup_inv_npvth=0.531
+mup_na_ppvth_lt=-0.474 mup_na_ppvth_rt=-0.928 mup_na_npvth_up=0.724 mup_na_npvth_dn=0.529
+mup_nb_ppvth_lt=-0.696 mup_nb_ppvth_rt=-0.983 mup_nb_npvth_up=0.231 mup_nb_npvth_dn=0.251
+mup_no_ppvth_lt=-0.008 mup_no_ppvth_rt=-0.135 mup_no_npvth_up=0.212 mup_no_npvth_dn=0.080

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.175 mdn_inv_npvth=0.236
+mdn_na_ppvth_lt=-0.046 mdn_na_ppvth_rt=-0.557 mdn_na_npvth_up=0.012 mdn_na_npvth_dn=0.154
+mdn_nb_ppvth_lt=-0.729 mdn_nb_ppvth_rt=-0.498 mdn_nb_npvth_up=0.320 mdn_nb_npvth_dn=0.548
+mdn_no_ppvth_lt=-0.029 mdn_no_ppvth_rt=-0.090 mdn_no_npvth_up=0.662 mdn_no_npvth_dn=0.359
**

** 68 PUF stage
xi67 gnd net134 net135 ch_67 net136 net137 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.100 mup_inv_npvth=0.405
+mup_na_ppvth_lt=-0.614 mup_na_ppvth_rt=-0.742 mup_na_npvth_up=0.861 mup_na_npvth_dn=0.079
+mup_nb_ppvth_lt=-0.190 mup_nb_ppvth_rt=-0.711 mup_nb_npvth_up=0.332 mup_nb_npvth_dn=0.693
+mup_no_ppvth_lt=-0.645 mup_no_ppvth_rt=-0.178 mup_no_npvth_up=0.285 mup_no_npvth_dn=0.081

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.966 mdn_inv_npvth=0.218
+mdn_na_ppvth_lt=-0.254 mdn_na_ppvth_rt=-0.383 mdn_na_npvth_up=0.079 mdn_na_npvth_dn=0.036
+mdn_nb_ppvth_lt=-0.209 mdn_nb_ppvth_rt=-0.170 mdn_nb_npvth_up=0.284 mdn_nb_npvth_dn=0.507
+mdn_no_ppvth_lt=-0.459 mdn_no_ppvth_rt=-0.845 mdn_no_npvth_up=0.335 mdn_no_npvth_dn=0.003
**

** 69 PUF stage
xi68 gnd net136 net137 ch_68 net138 net139 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.008 mup_inv_npvth=0.424
+mup_na_ppvth_lt=-0.343 mup_na_ppvth_rt=-0.208 mup_na_npvth_up=0.460 mup_na_npvth_dn=0.298
+mup_nb_ppvth_lt=-0.886 mup_nb_ppvth_rt=-0.750 mup_nb_npvth_up=0.465 mup_nb_npvth_dn=0.454
+mup_no_ppvth_lt=-0.008 mup_no_ppvth_rt=-0.116 mup_no_npvth_up=0.187 mup_no_npvth_dn=0.242

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.136 mdn_inv_npvth=0.547
+mdn_na_ppvth_lt=-0.140 mdn_na_ppvth_rt=-0.172 mdn_na_npvth_up=0.264 mdn_na_npvth_dn=0.126
+mdn_nb_ppvth_lt=-0.488 mdn_nb_ppvth_rt=-0.255 mdn_nb_npvth_up=0.790 mdn_nb_npvth_dn=0.516
+mdn_no_ppvth_lt=-0.351 mdn_no_ppvth_rt=-1.016 mdn_no_npvth_up=0.720 mdn_no_npvth_dn=0.278
**

** 70 PUF stage
xi69 gnd net138 net139 ch_69 net140 net141 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.889 mup_inv_npvth=0.902
+mup_na_ppvth_lt=-0.060 mup_na_ppvth_rt=-0.252 mup_na_npvth_up=0.606 mup_na_npvth_dn=1.196
+mup_nb_ppvth_lt=-0.285 mup_nb_ppvth_rt=-0.293 mup_nb_npvth_up=1.173 mup_nb_npvth_dn=0.183
+mup_no_ppvth_lt=-0.403 mup_no_ppvth_rt=-0.281 mup_no_npvth_up=0.342 mup_no_npvth_dn=0.146

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.296 mdn_inv_npvth=0.391
+mdn_na_ppvth_lt=-0.001 mdn_na_ppvth_rt=-0.005 mdn_na_npvth_up=0.215 mdn_na_npvth_dn=0.651
+mdn_nb_ppvth_lt=-0.385 mdn_nb_ppvth_rt=-0.006 mdn_nb_npvth_up=0.650 mdn_nb_npvth_dn=0.519
+mdn_no_ppvth_lt=-0.161 mdn_no_ppvth_rt=-0.311 mdn_no_npvth_up=0.035 mdn_no_npvth_dn=0.740
**

** 71 PUF stage
xi70 gnd net140 net141 ch_70 net142 net143 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-1.076 mup_inv_npvth=0.308
+mup_na_ppvth_lt=-0.621 mup_na_ppvth_rt=-0.226 mup_na_npvth_up=0.021 mup_na_npvth_dn=0.150
+mup_nb_ppvth_lt=-0.335 mup_nb_ppvth_rt=-0.282 mup_nb_npvth_up=0.437 mup_nb_npvth_dn=0.685
+mup_no_ppvth_lt=-0.293 mup_no_ppvth_rt=-0.099 mup_no_npvth_up=0.100 mup_no_npvth_dn=0.208

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.651 mdn_inv_npvth=0.096
+mdn_na_ppvth_lt=-0.918 mdn_na_ppvth_rt=-0.104 mdn_na_npvth_up=0.078 mdn_na_npvth_dn=0.104
+mdn_nb_ppvth_lt=-0.343 mdn_nb_ppvth_rt=-0.052 mdn_nb_npvth_up=0.103 mdn_nb_npvth_dn=0.281
+mdn_no_ppvth_lt=-0.131 mdn_no_ppvth_rt=-0.285 mdn_no_npvth_up=0.662 mdn_no_npvth_dn=0.005
**

** 72 PUF stage
xi71 gnd net142 net143 ch_71 net144 net145 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.100 mup_inv_npvth=0.758
+mup_na_ppvth_lt=-1.107 mup_na_ppvth_rt=-0.147 mup_na_npvth_up=0.269 mup_na_npvth_dn=0.132
+mup_nb_ppvth_lt=-0.274 mup_nb_ppvth_rt=-0.759 mup_nb_npvth_up=0.387 mup_nb_npvth_dn=0.442
+mup_no_ppvth_lt=-0.201 mup_no_ppvth_rt=-0.074 mup_no_npvth_up=0.423 mup_no_npvth_dn=0.095

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.194 mdn_inv_npvth=0.585
+mdn_na_ppvth_lt=-0.078 mdn_na_ppvth_rt=-0.178 mdn_na_npvth_up=0.014 mdn_na_npvth_dn=0.059
+mdn_nb_ppvth_lt=-0.477 mdn_nb_ppvth_rt=-0.501 mdn_nb_npvth_up=0.049 mdn_nb_npvth_dn=0.303
+mdn_no_ppvth_lt=-0.746 mdn_no_ppvth_rt=-0.524 mdn_no_npvth_up=0.310 mdn_no_npvth_dn=0.473
**

** 73 PUF stage
xi72 gnd net144 net145 ch_72 net146 net147 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.947 mup_inv_npvth=0.120
+mup_na_ppvth_lt=-0.252 mup_na_ppvth_rt=-1.319 mup_na_npvth_up=0.618 mup_na_npvth_dn=0.365
+mup_nb_ppvth_lt=-0.048 mup_nb_ppvth_rt=-0.547 mup_nb_npvth_up=0.324 mup_nb_npvth_dn=0.094
+mup_no_ppvth_lt=-0.416 mup_no_ppvth_rt=-0.249 mup_no_npvth_up=0.479 mup_no_npvth_dn=0.498

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.826 mdn_inv_npvth=0.046
+mdn_na_ppvth_lt=-0.137 mdn_na_ppvth_rt=-0.551 mdn_na_npvth_up=0.510 mdn_na_npvth_dn=0.507
+mdn_nb_ppvth_lt=-0.624 mdn_nb_ppvth_rt=-1.064 mdn_nb_npvth_up=0.747 mdn_nb_npvth_dn=0.253
+mdn_no_ppvth_lt=-0.290 mdn_no_ppvth_rt=-0.621 mdn_no_npvth_up=0.335 mdn_no_npvth_dn=0.498
**

** 74 PUF stage
xi73 gnd net146 net147 ch_73 net148 net149 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.204 mup_inv_npvth=0.603
+mup_na_ppvth_lt=-0.847 mup_na_ppvth_rt=-0.094 mup_na_npvth_up=0.293 mup_na_npvth_dn=0.319
+mup_nb_ppvth_lt=-0.424 mup_nb_ppvth_rt=-0.162 mup_nb_npvth_up=0.355 mup_nb_npvth_dn=0.414
+mup_no_ppvth_lt=-0.733 mup_no_ppvth_rt=-0.275 mup_no_npvth_up=0.465 mup_no_npvth_dn=0.550

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.085 mdn_inv_npvth=0.271
+mdn_na_ppvth_lt=-0.476 mdn_na_ppvth_rt=-0.133 mdn_na_npvth_up=0.083 mdn_na_npvth_dn=0.312
+mdn_nb_ppvth_lt=-0.715 mdn_nb_ppvth_rt=-0.523 mdn_nb_npvth_up=0.077 mdn_nb_npvth_dn=0.704
+mdn_no_ppvth_lt=-0.102 mdn_no_ppvth_rt=-0.773 mdn_no_npvth_up=0.088 mdn_no_npvth_dn=0.205
**

** 75 PUF stage
xi74 gnd net148 net149 ch_74 net150 net151 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-1.235 mup_inv_npvth=0.562
+mup_na_ppvth_lt=-0.078 mup_na_ppvth_rt=-0.245 mup_na_npvth_up=0.232 mup_na_npvth_dn=0.284
+mup_nb_ppvth_lt=-0.434 mup_nb_ppvth_rt=-0.002 mup_nb_npvth_up=0.117 mup_nb_npvth_dn=0.710
+mup_no_ppvth_lt=-0.416 mup_no_ppvth_rt=-0.180 mup_no_npvth_up=0.629 mup_no_npvth_dn=0.134

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.354 mdn_inv_npvth=0.478
+mdn_na_ppvth_lt=-0.495 mdn_na_ppvth_rt=-0.032 mdn_na_npvth_up=0.302 mdn_na_npvth_dn=0.715
+mdn_nb_ppvth_lt=-0.425 mdn_nb_ppvth_rt=-0.086 mdn_nb_npvth_up=0.386 mdn_nb_npvth_dn=0.446
+mdn_no_ppvth_lt=-0.492 mdn_no_ppvth_rt=-0.291 mdn_no_npvth_up=0.700 mdn_no_npvth_dn=0.100
**

** 76 PUF stage
xi75 gnd net150 net151 ch_75 net152 net153 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.132 mup_inv_npvth=0.261
+mup_na_ppvth_lt=-0.339 mup_na_ppvth_rt=-0.082 mup_na_npvth_up=0.026 mup_na_npvth_dn=0.558
+mup_nb_ppvth_lt=-0.016 mup_nb_ppvth_rt=-0.046 mup_nb_npvth_up=0.237 mup_nb_npvth_dn=0.094
+mup_no_ppvth_lt=-0.079 mup_no_ppvth_rt=-0.414 mup_no_npvth_up=0.452 mup_no_npvth_dn=0.466

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.509 mdn_inv_npvth=0.362
+mdn_na_ppvth_lt=-0.355 mdn_na_ppvth_rt=-0.183 mdn_na_npvth_up=0.120 mdn_na_npvth_dn=0.345
+mdn_nb_ppvth_lt=-0.082 mdn_nb_ppvth_rt=-0.082 mdn_nb_npvth_up=0.643 mdn_nb_npvth_dn=0.069
+mdn_no_ppvth_lt=-0.016 mdn_no_ppvth_rt=-0.181 mdn_no_npvth_up=0.098 mdn_no_npvth_dn=0.151
**

** 77 PUF stage
xi76 gnd net152 net153 ch_76 net154 net155 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.469 mup_inv_npvth=0.731
+mup_na_ppvth_lt=-0.053 mup_na_ppvth_rt=-0.306 mup_na_npvth_up=0.586 mup_na_npvth_dn=0.082
+mup_nb_ppvth_lt=-0.351 mup_nb_ppvth_rt=-0.203 mup_nb_npvth_up=0.450 mup_nb_npvth_dn=0.384
+mup_no_ppvth_lt=-0.234 mup_no_ppvth_rt=-0.356 mup_no_npvth_up=0.548 mup_no_npvth_dn=0.200

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.747 mdn_inv_npvth=0.151
+mdn_na_ppvth_lt=-0.297 mdn_na_ppvth_rt=-0.220 mdn_na_npvth_up=0.678 mdn_na_npvth_dn=0.174
+mdn_nb_ppvth_lt=-0.795 mdn_nb_ppvth_rt=-0.604 mdn_nb_npvth_up=0.820 mdn_nb_npvth_dn=0.424
+mdn_no_ppvth_lt=-0.611 mdn_no_ppvth_rt=-0.199 mdn_no_npvth_up=0.298 mdn_no_npvth_dn=0.223
**

** 78 PUF stage
xi77 gnd net154 net155 ch_77 net156 net157 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.788 mup_inv_npvth=0.866
+mup_na_ppvth_lt=-0.072 mup_na_ppvth_rt=-0.082 mup_na_npvth_up=0.714 mup_na_npvth_dn=0.076
+mup_nb_ppvth_lt=-0.241 mup_nb_ppvth_rt=-0.040 mup_nb_npvth_up=0.617 mup_nb_npvth_dn=0.048
+mup_no_ppvth_lt=-0.594 mup_no_ppvth_rt=-0.332 mup_no_npvth_up=0.622 mup_no_npvth_dn=0.782

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.843 mdn_inv_npvth=0.032
+mdn_na_ppvth_lt=-0.104 mdn_na_ppvth_rt=-0.488 mdn_na_npvth_up=0.160 mdn_na_npvth_dn=0.107
+mdn_nb_ppvth_lt=-0.469 mdn_nb_ppvth_rt=-0.656 mdn_nb_npvth_up=0.598 mdn_nb_npvth_dn=0.168
+mdn_no_ppvth_lt=-0.014 mdn_no_ppvth_rt=-0.657 mdn_no_npvth_up=0.540 mdn_no_npvth_dn=0.814
**

** 79 PUF stage
xi78 gnd net156 net157 ch_78 net158 net159 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.658 mup_inv_npvth=0.322
+mup_na_ppvth_lt=-0.533 mup_na_ppvth_rt=-0.471 mup_na_npvth_up=0.163 mup_na_npvth_dn=0.085
+mup_nb_ppvth_lt=-0.498 mup_nb_ppvth_rt=-0.317 mup_nb_npvth_up=0.975 mup_nb_npvth_dn=0.111
+mup_no_ppvth_lt=-0.105 mup_no_ppvth_rt=-0.376 mup_no_npvth_up=0.450 mup_no_npvth_dn=0.461

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.105 mdn_inv_npvth=0.508
+mdn_na_ppvth_lt=-0.123 mdn_na_ppvth_rt=-0.421 mdn_na_npvth_up=0.654 mdn_na_npvth_dn=0.003
+mdn_nb_ppvth_lt=-0.548 mdn_nb_ppvth_rt=-0.121 mdn_nb_npvth_up=0.482 mdn_nb_npvth_dn=0.366
+mdn_no_ppvth_lt=-0.467 mdn_no_ppvth_rt=-0.213 mdn_no_npvth_up=0.725 mdn_no_npvth_dn=0.671
**

** 80 PUF stage
xi79 gnd net158 net159 ch_79 net160 net161 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.254 mup_inv_npvth=0.229
+mup_na_ppvth_lt=-0.122 mup_na_ppvth_rt=-0.064 mup_na_npvth_up=0.545 mup_na_npvth_dn=0.087
+mup_nb_ppvth_lt=-0.281 mup_nb_ppvth_rt=-0.048 mup_nb_npvth_up=0.123 mup_nb_npvth_dn=0.206
+mup_no_ppvth_lt=-0.394 mup_no_ppvth_rt=-0.037 mup_no_npvth_up=0.791 mup_no_npvth_dn=0.189

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.605 mdn_inv_npvth=0.170
+mdn_na_ppvth_lt=-0.513 mdn_na_ppvth_rt=-0.599 mdn_na_npvth_up=0.205 mdn_na_npvth_dn=0.468
+mdn_nb_ppvth_lt=-0.096 mdn_nb_ppvth_rt=-0.005 mdn_nb_npvth_up=0.672 mdn_nb_npvth_dn=0.192
+mdn_no_ppvth_lt=-0.027 mdn_no_ppvth_rt=-0.416 mdn_no_npvth_up=0.240 mdn_no_npvth_dn=0.589
**

** 81 PUF stage
xi80 gnd net160 net161 ch_80 net162 net163 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.190 mup_inv_npvth=0.490
+mup_na_ppvth_lt=-0.679 mup_na_ppvth_rt=-0.155 mup_na_npvth_up=0.728 mup_na_npvth_dn=0.154
+mup_nb_ppvth_lt=-0.975 mup_nb_ppvth_rt=-0.281 mup_nb_npvth_up=0.793 mup_nb_npvth_dn=0.378
+mup_no_ppvth_lt=-0.431 mup_no_ppvth_rt=-0.260 mup_no_npvth_up=0.047 mup_no_npvth_dn=0.155

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.075 mdn_inv_npvth=0.409
+mdn_na_ppvth_lt=-0.448 mdn_na_ppvth_rt=-0.055 mdn_na_npvth_up=0.235 mdn_na_npvth_dn=0.455
+mdn_nb_ppvth_lt=-0.711 mdn_nb_ppvth_rt=-0.709 mdn_nb_npvth_up=0.321 mdn_nb_npvth_dn=0.391
+mdn_no_ppvth_lt=-0.312 mdn_no_ppvth_rt=-0.124 mdn_no_npvth_up=0.323 mdn_no_npvth_dn=0.388
**

** 82 PUF stage
xi81 gnd net162 net163 ch_81 net164 net165 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.236 mup_inv_npvth=0.239
+mup_na_ppvth_lt=-0.152 mup_na_ppvth_rt=-0.703 mup_na_npvth_up=0.167 mup_na_npvth_dn=0.312
+mup_nb_ppvth_lt=-0.680 mup_nb_ppvth_rt=-0.601 mup_nb_npvth_up=0.098 mup_nb_npvth_dn=0.556
+mup_no_ppvth_lt=-0.396 mup_no_ppvth_rt=-0.519 mup_no_npvth_up=0.172 mup_no_npvth_dn=0.428

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.347 mdn_inv_npvth=0.049
+mdn_na_ppvth_lt=-0.762 mdn_na_ppvth_rt=-0.234 mdn_na_npvth_up=0.308 mdn_na_npvth_dn=0.352
+mdn_nb_ppvth_lt=-0.240 mdn_nb_ppvth_rt=-0.583 mdn_nb_npvth_up=0.540 mdn_nb_npvth_dn=0.151
+mdn_no_ppvth_lt=-0.756 mdn_no_ppvth_rt=-0.517 mdn_no_npvth_up=0.463 mdn_no_npvth_dn=0.346
**

** 83 PUF stage
xi82 gnd net164 net165 ch_82 net166 net167 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.378 mup_inv_npvth=0.002
+mup_na_ppvth_lt=-0.770 mup_na_ppvth_rt=-0.476 mup_na_npvth_up=0.384 mup_na_npvth_dn=0.422
+mup_nb_ppvth_lt=-0.018 mup_nb_ppvth_rt=-0.044 mup_nb_npvth_up=0.363 mup_nb_npvth_dn=0.944
+mup_no_ppvth_lt=-0.319 mup_no_ppvth_rt=-0.628 mup_no_npvth_up=0.272 mup_no_npvth_dn=0.215

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-1.016 mdn_inv_npvth=0.141
+mdn_na_ppvth_lt=-0.363 mdn_na_ppvth_rt=-0.219 mdn_na_npvth_up=0.197 mdn_na_npvth_dn=0.040
+mdn_nb_ppvth_lt=-0.432 mdn_nb_ppvth_rt=-0.278 mdn_nb_npvth_up=0.526 mdn_nb_npvth_dn=0.655
+mdn_no_ppvth_lt=-0.091 mdn_no_ppvth_rt=-0.492 mdn_no_npvth_up=0.186 mdn_no_npvth_dn=0.458
**

** 84 PUF stage
xi83 gnd net166 net167 ch_83 net168 net169 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.277 mup_inv_npvth=0.584
+mup_na_ppvth_lt=-0.516 mup_na_ppvth_rt=-0.436 mup_na_npvth_up=0.553 mup_na_npvth_dn=0.526
+mup_nb_ppvth_lt=-0.204 mup_nb_ppvth_rt=-0.230 mup_nb_npvth_up=0.139 mup_nb_npvth_dn=0.383
+mup_no_ppvth_lt=-0.011 mup_no_ppvth_rt=-0.851 mup_no_npvth_up=0.198 mup_no_npvth_dn=0.581

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.704 mdn_inv_npvth=0.078
+mdn_na_ppvth_lt=-0.426 mdn_na_ppvth_rt=-0.034 mdn_na_npvth_up=0.167 mdn_na_npvth_dn=0.374
+mdn_nb_ppvth_lt=-0.067 mdn_nb_ppvth_rt=-0.366 mdn_nb_npvth_up=0.516 mdn_nb_npvth_dn=0.012
+mdn_no_ppvth_lt=-0.030 mdn_no_ppvth_rt=-0.368 mdn_no_npvth_up=0.582 mdn_no_npvth_dn=0.411
**

** 85 PUF stage
xi84 gnd net168 net169 ch_84 net170 net171 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.081 mup_inv_npvth=0.564
+mup_na_ppvth_lt=-0.325 mup_na_ppvth_rt=-0.092 mup_na_npvth_up=0.204 mup_na_npvth_dn=0.661
+mup_nb_ppvth_lt=-0.169 mup_nb_ppvth_rt=-0.334 mup_nb_npvth_up=0.111 mup_nb_npvth_dn=0.159
+mup_no_ppvth_lt=-0.552 mup_no_ppvth_rt=-0.285 mup_no_npvth_up=0.312 mup_no_npvth_dn=0.821

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.038 mdn_inv_npvth=0.013
+mdn_na_ppvth_lt=-0.360 mdn_na_ppvth_rt=-0.114 mdn_na_npvth_up=0.082 mdn_na_npvth_dn=0.148
+mdn_nb_ppvth_lt=-0.026 mdn_nb_ppvth_rt=-0.608 mdn_nb_npvth_up=0.452 mdn_nb_npvth_dn=0.111
+mdn_no_ppvth_lt=-0.463 mdn_no_ppvth_rt=-0.141 mdn_no_npvth_up=0.194 mdn_no_npvth_dn=0.234
**

** 86 PUF stage
xi85 gnd net170 net171 ch_85 net172 net173 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.445 mup_inv_npvth=0.469
+mup_na_ppvth_lt=-0.021 mup_na_ppvth_rt=-0.471 mup_na_npvth_up=0.152 mup_na_npvth_dn=0.582
+mup_nb_ppvth_lt=-0.084 mup_nb_ppvth_rt=-0.896 mup_nb_npvth_up=0.269 mup_nb_npvth_dn=0.051
+mup_no_ppvth_lt=-0.494 mup_no_ppvth_rt=-0.650 mup_no_npvth_up=0.621 mup_no_npvth_dn=0.753

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.021 mdn_inv_npvth=0.381
+mdn_na_ppvth_lt=-0.257 mdn_na_ppvth_rt=-0.175 mdn_na_npvth_up=0.388 mdn_na_npvth_dn=0.668
+mdn_nb_ppvth_lt=-0.663 mdn_nb_ppvth_rt=-0.572 mdn_nb_npvth_up=0.371 mdn_nb_npvth_dn=0.408
+mdn_no_ppvth_lt=-0.311 mdn_no_ppvth_rt=-0.294 mdn_no_npvth_up=0.051 mdn_no_npvth_dn=0.054
**

** 87 PUF stage
xi86 gnd net172 net173 ch_86 net174 net175 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.041 mup_inv_npvth=0.506
+mup_na_ppvth_lt=-0.146 mup_na_ppvth_rt=-0.574 mup_na_npvth_up=0.226 mup_na_npvth_dn=0.026
+mup_nb_ppvth_lt=-0.149 mup_nb_ppvth_rt=-0.134 mup_nb_npvth_up=0.351 mup_nb_npvth_dn=0.277
+mup_no_ppvth_lt=-0.055 mup_no_ppvth_rt=-0.740 mup_no_npvth_up=0.275 mup_no_npvth_dn=0.252

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.389 mdn_inv_npvth=0.397
+mdn_na_ppvth_lt=-0.168 mdn_na_ppvth_rt=-0.272 mdn_na_npvth_up=0.425 mdn_na_npvth_dn=0.065
+mdn_nb_ppvth_lt=-0.515 mdn_nb_ppvth_rt=-0.254 mdn_nb_npvth_up=0.281 mdn_nb_npvth_dn=0.550
+mdn_no_ppvth_lt=-0.408 mdn_no_ppvth_rt=-0.355 mdn_no_npvth_up=0.038 mdn_no_npvth_dn=0.251
**

** 88 PUF stage
xi87 gnd net174 net175 ch_87 net176 net177 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.160 mup_inv_npvth=0.140
+mup_na_ppvth_lt=-0.047 mup_na_ppvth_rt=-0.682 mup_na_npvth_up=0.089 mup_na_npvth_dn=0.058
+mup_nb_ppvth_lt=-0.430 mup_nb_ppvth_rt=-0.884 mup_nb_npvth_up=0.553 mup_nb_npvth_dn=0.237
+mup_no_ppvth_lt=-0.031 mup_no_ppvth_rt=-0.618 mup_no_npvth_up=0.334 mup_no_npvth_dn=0.429

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.120 mdn_inv_npvth=0.615
+mdn_na_ppvth_lt=-1.060 mdn_na_ppvth_rt=-0.580 mdn_na_npvth_up=0.505 mdn_na_npvth_dn=0.650
+mdn_nb_ppvth_lt=-0.194 mdn_nb_ppvth_rt=-0.828 mdn_nb_npvth_up=0.414 mdn_nb_npvth_dn=0.507
+mdn_no_ppvth_lt=-0.002 mdn_no_ppvth_rt=-0.291 mdn_no_npvth_up=0.136 mdn_no_npvth_dn=0.217
**

** 89 PUF stage
xi88 gnd net176 net177 ch_88 net178 net179 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.566 mup_inv_npvth=0.738
+mup_na_ppvth_lt=-0.121 mup_na_ppvth_rt=-0.835 mup_na_npvth_up=0.350 mup_na_npvth_dn=1.002
+mup_nb_ppvth_lt=-0.146 mup_nb_ppvth_rt=-0.896 mup_nb_npvth_up=0.174 mup_nb_npvth_dn=0.249
+mup_no_ppvth_lt=-0.182 mup_no_ppvth_rt=-0.186 mup_no_npvth_up=0.761 mup_no_npvth_dn=0.365

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.325 mdn_inv_npvth=0.627
+mdn_na_ppvth_lt=-0.623 mdn_na_ppvth_rt=-0.004 mdn_na_npvth_up=0.100 mdn_na_npvth_dn=0.421
+mdn_nb_ppvth_lt=-0.117 mdn_nb_ppvth_rt=-0.746 mdn_nb_npvth_up=0.198 mdn_nb_npvth_dn=0.143
+mdn_no_ppvth_lt=-0.494 mdn_no_ppvth_rt=-0.245 mdn_no_npvth_up=0.030 mdn_no_npvth_dn=0.074
**

** 90 PUF stage
xi89 gnd net178 net179 ch_89 net180 net181 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.255 mup_inv_npvth=0.052
+mup_na_ppvth_lt=-0.246 mup_na_ppvth_rt=-0.349 mup_na_npvth_up=0.238 mup_na_npvth_dn=0.495
+mup_nb_ppvth_lt=-0.401 mup_nb_ppvth_rt=-0.043 mup_nb_npvth_up=0.408 mup_nb_npvth_dn=0.737
+mup_no_ppvth_lt=-0.369 mup_no_ppvth_rt=-0.313 mup_no_npvth_up=0.329 mup_no_npvth_dn=0.247

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.609 mdn_inv_npvth=0.444
+mdn_na_ppvth_lt=-0.902 mdn_na_ppvth_rt=-0.402 mdn_na_npvth_up=0.213 mdn_na_npvth_dn=0.738
+mdn_nb_ppvth_lt=-0.193 mdn_nb_ppvth_rt=-0.428 mdn_nb_npvth_up=0.320 mdn_nb_npvth_dn=0.175
+mdn_no_ppvth_lt=-0.407 mdn_no_ppvth_rt=-0.246 mdn_no_npvth_up=0.479 mdn_no_npvth_dn=0.214
**

** 91 PUF stage
xi90 gnd net180 net181 ch_90 net182 net183 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.466 mup_inv_npvth=0.441
+mup_na_ppvth_lt=-0.333 mup_na_ppvth_rt=-0.123 mup_na_npvth_up=0.433 mup_na_npvth_dn=0.264
+mup_nb_ppvth_lt=-0.662 mup_nb_ppvth_rt=-0.335 mup_nb_npvth_up=0.357 mup_nb_npvth_dn=0.643
+mup_no_ppvth_lt=-0.433 mup_no_ppvth_rt=-0.217 mup_no_npvth_up=0.431 mup_no_npvth_dn=0.136

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.044 mdn_inv_npvth=0.600
+mdn_na_ppvth_lt=-0.356 mdn_na_ppvth_rt=-0.020 mdn_na_npvth_up=0.144 mdn_na_npvth_dn=0.172
+mdn_nb_ppvth_lt=-0.724 mdn_nb_ppvth_rt=-0.249 mdn_nb_npvth_up=0.323 mdn_nb_npvth_dn=0.195
+mdn_no_ppvth_lt=-0.573 mdn_no_ppvth_rt=-0.393 mdn_no_npvth_up=1.144 mdn_no_npvth_dn=0.262
**

** 92 PUF stage
xi91 gnd net182 net183 ch_91 net184 net185 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.543 mup_inv_npvth=0.461
+mup_na_ppvth_lt=-0.356 mup_na_ppvth_rt=-0.455 mup_na_npvth_up=0.055 mup_na_npvth_dn=0.871
+mup_nb_ppvth_lt=-0.505 mup_nb_ppvth_rt=-0.040 mup_nb_npvth_up=0.288 mup_nb_npvth_dn=0.523
+mup_no_ppvth_lt=-0.135 mup_no_ppvth_rt=-0.293 mup_no_npvth_up=0.389 mup_no_npvth_dn=0.313

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.120 mdn_inv_npvth=0.391
+mdn_na_ppvth_lt=-0.118 mdn_na_ppvth_rt=-0.150 mdn_na_npvth_up=0.095 mdn_na_npvth_dn=0.134
+mdn_nb_ppvth_lt=-0.709 mdn_nb_ppvth_rt=-0.309 mdn_nb_npvth_up=0.059 mdn_nb_npvth_dn=0.802
+mdn_no_ppvth_lt=-0.402 mdn_no_ppvth_rt=-0.316 mdn_no_npvth_up=0.204 mdn_no_npvth_dn=0.349
**

** 93 PUF stage
xi92 gnd net184 net185 ch_92 net186 net187 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.416 mup_inv_npvth=0.527
+mup_na_ppvth_lt=-0.193 mup_na_ppvth_rt=-0.257 mup_na_npvth_up=0.566 mup_na_npvth_dn=0.188
+mup_nb_ppvth_lt=-0.092 mup_nb_ppvth_rt=-0.042 mup_nb_npvth_up=0.080 mup_nb_npvth_dn=0.203
+mup_no_ppvth_lt=-0.382 mup_no_ppvth_rt=-0.255 mup_no_npvth_up=0.082 mup_no_npvth_dn=0.128

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.265 mdn_inv_npvth=0.134
+mdn_na_ppvth_lt=-0.433 mdn_na_ppvth_rt=-0.639 mdn_na_npvth_up=0.097 mdn_na_npvth_dn=0.560
+mdn_nb_ppvth_lt=-0.147 mdn_nb_ppvth_rt=-0.103 mdn_nb_npvth_up=0.016 mdn_nb_npvth_dn=0.144
+mdn_no_ppvth_lt=-0.390 mdn_no_ppvth_rt=-0.404 mdn_no_npvth_up=0.799 mdn_no_npvth_dn=0.033
**

** 94 PUF stage
xi93 gnd net186 net187 ch_93 net188 net189 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.427 mup_inv_npvth=0.356
+mup_na_ppvth_lt=-0.437 mup_na_ppvth_rt=-0.340 mup_na_npvth_up=0.235 mup_na_npvth_dn=0.001
+mup_nb_ppvth_lt=-0.244 mup_nb_ppvth_rt=-0.510 mup_nb_npvth_up=0.574 mup_nb_npvth_dn=0.080
+mup_no_ppvth_lt=-0.455 mup_no_ppvth_rt=-0.266 mup_no_npvth_up=0.634 mup_no_npvth_dn=0.168

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.636 mdn_inv_npvth=0.241
+mdn_na_ppvth_lt=-0.003 mdn_na_ppvth_rt=-0.041 mdn_na_npvth_up=0.037 mdn_na_npvth_dn=0.928
+mdn_nb_ppvth_lt=-0.337 mdn_nb_ppvth_rt=-0.570 mdn_nb_npvth_up=0.205 mdn_nb_npvth_dn=0.335
+mdn_no_ppvth_lt=-0.223 mdn_no_ppvth_rt=-1.134 mdn_no_npvth_up=0.328 mdn_no_npvth_dn=0.330
**

** 95 PUF stage
xi94 gnd net188 net189 ch_94 net190 net191 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.631 mup_inv_npvth=0.372
+mup_na_ppvth_lt=-0.392 mup_na_ppvth_rt=-0.496 mup_na_npvth_up=0.137 mup_na_npvth_dn=0.109
+mup_nb_ppvth_lt=-0.741 mup_nb_ppvth_rt=-0.196 mup_nb_npvth_up=0.351 mup_nb_npvth_dn=0.234
+mup_no_ppvth_lt=-0.832 mup_no_ppvth_rt=-0.000 mup_no_npvth_up=0.624 mup_no_npvth_dn=0.350

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.319 mdn_inv_npvth=0.290
+mdn_na_ppvth_lt=-0.147 mdn_na_ppvth_rt=-0.015 mdn_na_npvth_up=0.253 mdn_na_npvth_dn=0.107
+mdn_nb_ppvth_lt=-0.316 mdn_nb_ppvth_rt=-0.279 mdn_nb_npvth_up=0.295 mdn_nb_npvth_dn=0.840
+mdn_no_ppvth_lt=-0.294 mdn_no_ppvth_rt=-0.458 mdn_no_npvth_up=0.110 mdn_no_npvth_dn=0.343
**

** 96 PUF stage
xi95 gnd net190 net191 ch_95 net192 net193 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.397 mup_inv_npvth=0.497
+mup_na_ppvth_lt=-0.142 mup_na_ppvth_rt=-0.602 mup_na_npvth_up=0.675 mup_na_npvth_dn=0.218
+mup_nb_ppvth_lt=-0.311 mup_nb_ppvth_rt=-0.488 mup_nb_npvth_up=0.401 mup_nb_npvth_dn=0.131
+mup_no_ppvth_lt=-0.022 mup_no_ppvth_rt=-0.581 mup_no_npvth_up=0.515 mup_no_npvth_dn=0.519

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.223 mdn_inv_npvth=0.213
+mdn_na_ppvth_lt=-0.042 mdn_na_ppvth_rt=-0.277 mdn_na_npvth_up=0.461 mdn_na_npvth_dn=0.793
+mdn_nb_ppvth_lt=-0.107 mdn_nb_ppvth_rt=-0.585 mdn_nb_npvth_up=0.319 mdn_nb_npvth_dn=0.182
+mdn_no_ppvth_lt=-0.301 mdn_no_ppvth_rt=-0.443 mdn_no_npvth_up=0.607 mdn_no_npvth_dn=0.559
**

** 97 PUF stage
xi96 gnd net192 net193 ch_96 net194 net195 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.021 mup_inv_npvth=0.332
+mup_na_ppvth_lt=-0.557 mup_na_ppvth_rt=-0.339 mup_na_npvth_up=0.586 mup_na_npvth_dn=0.164
+mup_nb_ppvth_lt=-0.168 mup_nb_ppvth_rt=-0.128 mup_nb_npvth_up=0.422 mup_nb_npvth_dn=0.317
+mup_no_ppvth_lt=-0.165 mup_no_ppvth_rt=-0.866 mup_no_npvth_up=0.030 mup_no_npvth_dn=0.234

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.248 mdn_inv_npvth=0.497
+mdn_na_ppvth_lt=-0.266 mdn_na_ppvth_rt=-0.122 mdn_na_npvth_up=0.492 mdn_na_npvth_dn=0.249
+mdn_nb_ppvth_lt=-0.164 mdn_nb_ppvth_rt=-0.169 mdn_nb_npvth_up=0.073 mdn_nb_npvth_dn=0.508
+mdn_no_ppvth_lt=-0.105 mdn_no_ppvth_rt=-0.141 mdn_no_npvth_up=0.655 mdn_no_npvth_dn=0.373
**

** 98 PUF stage
xi97 gnd net194 net195 ch_97 net196 net197 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.442 mup_inv_npvth=0.732
+mup_na_ppvth_lt=-0.260 mup_na_ppvth_rt=-0.190 mup_na_npvth_up=0.205 mup_na_npvth_dn=0.155
+mup_nb_ppvth_lt=-0.137 mup_nb_ppvth_rt=-0.402 mup_nb_npvth_up=0.238 mup_nb_npvth_dn=0.045
+mup_no_ppvth_lt=-0.378 mup_no_ppvth_rt=-0.393 mup_no_npvth_up=0.958 mup_no_npvth_dn=0.571

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.176 mdn_inv_npvth=0.228
+mdn_na_ppvth_lt=-0.379 mdn_na_ppvth_rt=-0.367 mdn_na_npvth_up=0.317 mdn_na_npvth_dn=0.446
+mdn_nb_ppvth_lt=-0.226 mdn_nb_ppvth_rt=-0.008 mdn_nb_npvth_up=0.376 mdn_nb_npvth_dn=0.226
+mdn_no_ppvth_lt=-0.060 mdn_no_ppvth_rt=-0.236 mdn_no_npvth_up=0.003 mdn_no_npvth_dn=0.347
**

** 99 PUF stage
xi98 gnd net196 net197 ch_98 net198 net199 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.426 mup_inv_npvth=0.175
+mup_na_ppvth_lt=-0.027 mup_na_ppvth_rt=-0.232 mup_na_npvth_up=0.026 mup_na_npvth_dn=0.495
+mup_nb_ppvth_lt=-0.279 mup_nb_ppvth_rt=-0.401 mup_nb_npvth_up=0.546 mup_nb_npvth_dn=0.647
+mup_no_ppvth_lt=-0.540 mup_no_ppvth_rt=-0.389 mup_no_npvth_up=0.313 mup_no_npvth_dn=0.137

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.112 mdn_inv_npvth=0.052
+mdn_na_ppvth_lt=-0.199 mdn_na_ppvth_rt=-0.238 mdn_na_npvth_up=0.118 mdn_na_npvth_dn=0.074
+mdn_nb_ppvth_lt=-0.193 mdn_nb_ppvth_rt=-0.240 mdn_nb_npvth_up=0.268 mdn_nb_npvth_dn=0.400
+mdn_no_ppvth_lt=-0.673 mdn_no_ppvth_rt=-1.100 mdn_no_npvth_up=0.630 mdn_no_npvth_dn=0.489
**

** 100 PUF stage
xi99 gnd net198 net199 ch_99 net200 net201 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.520 mup_inv_npvth=0.372
+mup_na_ppvth_lt=-0.024 mup_na_ppvth_rt=-0.397 mup_na_npvth_up=0.348 mup_na_npvth_dn=0.397
+mup_nb_ppvth_lt=-0.230 mup_nb_ppvth_rt=-0.243 mup_nb_npvth_up=0.476 mup_nb_npvth_dn=0.236
+mup_no_ppvth_lt=-0.461 mup_no_ppvth_rt=-0.104 mup_no_npvth_up=0.158 mup_no_npvth_dn=0.053

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.492 mdn_inv_npvth=0.259
+mdn_na_ppvth_lt=-0.176 mdn_na_ppvth_rt=-0.138 mdn_na_npvth_up=1.122 mdn_na_npvth_dn=0.081
+mdn_nb_ppvth_lt=-0.876 mdn_nb_ppvth_rt=-1.085 mdn_nb_npvth_up=0.206 mdn_nb_npvth_dn=0.715
+mdn_no_ppvth_lt=-0.245 mdn_no_ppvth_rt=-1.037 mdn_no_npvth_up=0.391 mdn_no_npvth_dn=0.117
**

** 101 PUF stage
xi100 gnd net200 net201 ch_100 net202 net203 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.469 mup_inv_npvth=0.502
+mup_na_ppvth_lt=-0.848 mup_na_ppvth_rt=-0.158 mup_na_npvth_up=0.050 mup_na_npvth_dn=0.394
+mup_nb_ppvth_lt=-0.269 mup_nb_ppvth_rt=-0.174 mup_nb_npvth_up=0.186 mup_nb_npvth_dn=0.340
+mup_no_ppvth_lt=-0.120 mup_no_ppvth_rt=-0.329 mup_no_npvth_up=0.303 mup_no_npvth_dn=0.239

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.342 mdn_inv_npvth=0.328
+mdn_na_ppvth_lt=-0.061 mdn_na_ppvth_rt=-0.478 mdn_na_npvth_up=0.583 mdn_na_npvth_dn=0.039
+mdn_nb_ppvth_lt=-0.115 mdn_nb_ppvth_rt=-0.251 mdn_nb_npvth_up=0.326 mdn_nb_npvth_dn=0.328
+mdn_no_ppvth_lt=-0.044 mdn_no_ppvth_rt=-0.211 mdn_no_npvth_up=0.106 mdn_no_npvth_dn=0.450
**

** 102 PUF stage
xi101 gnd net202 net203 ch_101 net204 net205 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.656 mup_inv_npvth=0.844
+mup_na_ppvth_lt=-1.001 mup_na_ppvth_rt=-0.233 mup_na_npvth_up=0.572 mup_na_npvth_dn=0.894
+mup_nb_ppvth_lt=-0.040 mup_nb_ppvth_rt=-0.355 mup_nb_npvth_up=0.385 mup_nb_npvth_dn=0.556
+mup_no_ppvth_lt=-0.305 mup_no_ppvth_rt=-0.476 mup_no_npvth_up=0.514 mup_no_npvth_dn=0.287

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.456 mdn_inv_npvth=0.541
+mdn_na_ppvth_lt=-0.014 mdn_na_ppvth_rt=-0.200 mdn_na_npvth_up=0.636 mdn_na_npvth_dn=0.517
+mdn_nb_ppvth_lt=-0.158 mdn_nb_ppvth_rt=-0.929 mdn_nb_npvth_up=0.564 mdn_nb_npvth_dn=0.567
+mdn_no_ppvth_lt=-0.259 mdn_no_ppvth_rt=-0.391 mdn_no_npvth_up=0.187 mdn_no_npvth_dn=0.725
**

** 103 PUF stage
xi102 gnd net204 net205 ch_102 net206 net207 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.368 mup_inv_npvth=0.578
+mup_na_ppvth_lt=-0.004 mup_na_ppvth_rt=-0.343 mup_na_npvth_up=0.104 mup_na_npvth_dn=0.877
+mup_nb_ppvth_lt=-0.032 mup_nb_ppvth_rt=-0.224 mup_nb_npvth_up=0.192 mup_nb_npvth_dn=0.057
+mup_no_ppvth_lt=-0.366 mup_no_ppvth_rt=-0.040 mup_no_npvth_up=0.007 mup_no_npvth_dn=0.484

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.378 mdn_inv_npvth=0.378
+mdn_na_ppvth_lt=-0.114 mdn_na_ppvth_rt=-0.489 mdn_na_npvth_up=0.399 mdn_na_npvth_dn=0.149
+mdn_nb_ppvth_lt=-0.215 mdn_nb_ppvth_rt=-0.034 mdn_nb_npvth_up=0.028 mdn_nb_npvth_dn=0.108
+mdn_no_ppvth_lt=-0.202 mdn_no_ppvth_rt=-0.608 mdn_no_npvth_up=0.240 mdn_no_npvth_dn=0.146
**

** 104 PUF stage
xi103 gnd net206 net207 ch_103 net208 net209 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.053 mup_inv_npvth=0.384
+mup_na_ppvth_lt=-0.281 mup_na_ppvth_rt=-0.092 mup_na_npvth_up=0.080 mup_na_npvth_dn=0.156
+mup_nb_ppvth_lt=-0.197 mup_nb_ppvth_rt=-0.060 mup_nb_npvth_up=0.175 mup_nb_npvth_dn=0.537
+mup_no_ppvth_lt=-0.385 mup_no_ppvth_rt=-0.692 mup_no_npvth_up=0.272 mup_no_npvth_dn=0.152

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.224 mdn_inv_npvth=0.094
+mdn_na_ppvth_lt=-0.126 mdn_na_ppvth_rt=-0.591 mdn_na_npvth_up=0.245 mdn_na_npvth_dn=0.414
+mdn_nb_ppvth_lt=-0.230 mdn_nb_ppvth_rt=-0.593 mdn_nb_npvth_up=0.352 mdn_nb_npvth_dn=0.370
+mdn_no_ppvth_lt=-0.592 mdn_no_ppvth_rt=-0.321 mdn_no_npvth_up=0.710 mdn_no_npvth_dn=0.262
**

** 105 PUF stage
xi104 gnd net208 net209 ch_104 net210 net211 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.639 mup_inv_npvth=0.414
+mup_na_ppvth_lt=-0.479 mup_na_ppvth_rt=-0.304 mup_na_npvth_up=0.327 mup_na_npvth_dn=0.541
+mup_nb_ppvth_lt=-0.447 mup_nb_ppvth_rt=-0.177 mup_nb_npvth_up=0.289 mup_nb_npvth_dn=0.646
+mup_no_ppvth_lt=-0.552 mup_no_ppvth_rt=-0.353 mup_no_npvth_up=0.932 mup_no_npvth_dn=0.036

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.383 mdn_inv_npvth=0.249
+mdn_na_ppvth_lt=-0.699 mdn_na_ppvth_rt=-0.234 mdn_na_npvth_up=0.678 mdn_na_npvth_dn=0.491
+mdn_nb_ppvth_lt=-0.825 mdn_nb_ppvth_rt=-0.270 mdn_nb_npvth_up=1.021 mdn_nb_npvth_dn=0.292
+mdn_no_ppvth_lt=-0.075 mdn_no_ppvth_rt=-0.215 mdn_no_npvth_up=0.669 mdn_no_npvth_dn=0.390
**

** 106 PUF stage
xi105 gnd net210 net211 ch_105 net212 net213 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.257 mup_inv_npvth=0.042
+mup_na_ppvth_lt=-0.083 mup_na_ppvth_rt=-0.397 mup_na_npvth_up=0.243 mup_na_npvth_dn=0.044
+mup_nb_ppvth_lt=-0.456 mup_nb_ppvth_rt=-0.367 mup_nb_npvth_up=0.532 mup_nb_npvth_dn=0.354
+mup_no_ppvth_lt=-0.011 mup_no_ppvth_rt=-0.955 mup_no_npvth_up=0.029 mup_no_npvth_dn=0.149

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.401 mdn_inv_npvth=0.140
+mdn_na_ppvth_lt=-0.746 mdn_na_ppvth_rt=-0.167 mdn_na_npvth_up=0.123 mdn_na_npvth_dn=0.577
+mdn_nb_ppvth_lt=-0.009 mdn_nb_ppvth_rt=-0.368 mdn_nb_npvth_up=0.687 mdn_nb_npvth_dn=0.975
+mdn_no_ppvth_lt=-0.166 mdn_no_ppvth_rt=-0.219 mdn_no_npvth_up=0.369 mdn_no_npvth_dn=0.023
**

** 107 PUF stage
xi106 gnd net212 net213 ch_106 net214 net215 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.431 mup_inv_npvth=0.432
+mup_na_ppvth_lt=-0.085 mup_na_ppvth_rt=-0.613 mup_na_npvth_up=0.505 mup_na_npvth_dn=0.466
+mup_nb_ppvth_lt=-0.436 mup_nb_ppvth_rt=-0.382 mup_nb_npvth_up=0.228 mup_nb_npvth_dn=0.674
+mup_no_ppvth_lt=-0.203 mup_no_ppvth_rt=-0.204 mup_no_npvth_up=0.938 mup_no_npvth_dn=0.218

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.037 mdn_inv_npvth=0.220
+mdn_na_ppvth_lt=-0.135 mdn_na_ppvth_rt=-0.450 mdn_na_npvth_up=0.087 mdn_na_npvth_dn=0.024
+mdn_nb_ppvth_lt=-0.157 mdn_nb_ppvth_rt=-0.025 mdn_nb_npvth_up=0.300 mdn_nb_npvth_dn=0.185
+mdn_no_ppvth_lt=-0.100 mdn_no_ppvth_rt=-0.773 mdn_no_npvth_up=0.040 mdn_no_npvth_dn=0.480
**

** 108 PUF stage
xi107 gnd net214 net215 ch_107 net216 net217 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.530 mup_inv_npvth=0.136
+mup_na_ppvth_lt=-0.082 mup_na_ppvth_rt=-0.383 mup_na_npvth_up=0.436 mup_na_npvth_dn=0.072
+mup_nb_ppvth_lt=-0.157 mup_nb_ppvth_rt=-0.362 mup_nb_npvth_up=0.005 mup_nb_npvth_dn=0.459
+mup_no_ppvth_lt=-0.328 mup_no_ppvth_rt=-0.359 mup_no_npvth_up=0.069 mup_no_npvth_dn=0.355

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.324 mdn_inv_npvth=0.026
+mdn_na_ppvth_lt=-0.250 mdn_na_ppvth_rt=-0.697 mdn_na_npvth_up=0.427 mdn_na_npvth_dn=0.621
+mdn_nb_ppvth_lt=-0.311 mdn_nb_ppvth_rt=-0.720 mdn_nb_npvth_up=0.952 mdn_nb_npvth_dn=0.439
+mdn_no_ppvth_lt=-0.030 mdn_no_ppvth_rt=-0.221 mdn_no_npvth_up=0.314 mdn_no_npvth_dn=0.602
**

** 109 PUF stage
xi108 gnd net216 net217 ch_108 net218 net219 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.037 mup_inv_npvth=0.299
+mup_na_ppvth_lt=-0.614 mup_na_ppvth_rt=-0.547 mup_na_npvth_up=0.220 mup_na_npvth_dn=0.634
+mup_nb_ppvth_lt=-0.215 mup_nb_ppvth_rt=-0.610 mup_nb_npvth_up=1.120 mup_nb_npvth_dn=0.608
+mup_no_ppvth_lt=-0.032 mup_no_ppvth_rt=-0.636 mup_no_npvth_up=0.424 mup_no_npvth_dn=0.009

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.294 mdn_inv_npvth=0.035
+mdn_na_ppvth_lt=-0.220 mdn_na_ppvth_rt=-0.317 mdn_na_npvth_up=0.391 mdn_na_npvth_dn=0.043
+mdn_nb_ppvth_lt=-0.894 mdn_nb_ppvth_rt=-0.366 mdn_nb_npvth_up=0.043 mdn_nb_npvth_dn=0.181
+mdn_no_ppvth_lt=-0.031 mdn_no_ppvth_rt=-0.560 mdn_no_npvth_up=0.573 mdn_no_npvth_dn=0.442
**

** 110 PUF stage
xi109 gnd net218 net219 ch_109 net220 net221 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.543 mup_inv_npvth=0.137
+mup_na_ppvth_lt=-0.553 mup_na_ppvth_rt=-0.102 mup_na_npvth_up=0.557 mup_na_npvth_dn=0.337
+mup_nb_ppvth_lt=-0.244 mup_nb_ppvth_rt=-0.530 mup_nb_npvth_up=0.585 mup_nb_npvth_dn=0.421
+mup_no_ppvth_lt=-0.534 mup_no_ppvth_rt=-0.094 mup_no_npvth_up=0.531 mup_no_npvth_dn=0.068

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.228 mdn_inv_npvth=0.062
+mdn_na_ppvth_lt=-0.378 mdn_na_ppvth_rt=-0.427 mdn_na_npvth_up=0.186 mdn_na_npvth_dn=0.469
+mdn_nb_ppvth_lt=-0.144 mdn_nb_ppvth_rt=-0.145 mdn_nb_npvth_up=0.011 mdn_nb_npvth_dn=0.384
+mdn_no_ppvth_lt=-0.108 mdn_no_ppvth_rt=-0.483 mdn_no_npvth_up=0.250 mdn_no_npvth_dn=0.012
**

** 111 PUF stage
xi110 gnd net220 net221 ch_110 net222 net223 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.016 mup_inv_npvth=0.280
+mup_na_ppvth_lt=-0.086 mup_na_ppvth_rt=-0.141 mup_na_npvth_up=0.179 mup_na_npvth_dn=0.417
+mup_nb_ppvth_lt=-0.090 mup_nb_ppvth_rt=-0.186 mup_nb_npvth_up=0.379 mup_nb_npvth_dn=0.460
+mup_no_ppvth_lt=-0.296 mup_no_ppvth_rt=-0.308 mup_no_npvth_up=0.695 mup_no_npvth_dn=0.392

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.072 mdn_inv_npvth=0.529
+mdn_na_ppvth_lt=-0.178 mdn_na_ppvth_rt=-0.056 mdn_na_npvth_up=1.079 mdn_na_npvth_dn=0.506
+mdn_nb_ppvth_lt=-0.558 mdn_nb_ppvth_rt=-0.929 mdn_nb_npvth_up=0.075 mdn_nb_npvth_dn=0.199
+mdn_no_ppvth_lt=-0.456 mdn_no_ppvth_rt=-0.256 mdn_no_npvth_up=0.175 mdn_no_npvth_dn=0.173
**

** 112 PUF stage
xi111 gnd net222 net223 ch_111 net224 net225 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.266 mup_inv_npvth=0.226
+mup_na_ppvth_lt=-0.546 mup_na_ppvth_rt=-0.183 mup_na_npvth_up=0.523 mup_na_npvth_dn=0.062
+mup_nb_ppvth_lt=-0.627 mup_nb_ppvth_rt=-0.669 mup_nb_npvth_up=0.067 mup_nb_npvth_dn=0.349
+mup_no_ppvth_lt=-0.341 mup_no_ppvth_rt=-0.260 mup_no_npvth_up=0.833 mup_no_npvth_dn=0.096

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.169 mdn_inv_npvth=0.676
+mdn_na_ppvth_lt=-0.468 mdn_na_ppvth_rt=-0.082 mdn_na_npvth_up=0.152 mdn_na_npvth_dn=0.352
+mdn_nb_ppvth_lt=-0.327 mdn_nb_ppvth_rt=-0.608 mdn_nb_npvth_up=0.505 mdn_nb_npvth_dn=0.433
+mdn_no_ppvth_lt=-0.049 mdn_no_ppvth_rt=-0.484 mdn_no_npvth_up=0.365 mdn_no_npvth_dn=0.509
**

** 113 PUF stage
xi112 gnd net224 net225 ch_112 net226 net227 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.723 mup_inv_npvth=0.153
+mup_na_ppvth_lt=-0.243 mup_na_ppvth_rt=-0.149 mup_na_npvth_up=0.211 mup_na_npvth_dn=0.483
+mup_nb_ppvth_lt=-0.236 mup_nb_ppvth_rt=-0.781 mup_nb_npvth_up=0.318 mup_nb_npvth_dn=0.646
+mup_no_ppvth_lt=-0.143 mup_no_ppvth_rt=-0.398 mup_no_npvth_up=0.362 mup_no_npvth_dn=0.248

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.430 mdn_inv_npvth=0.361
+mdn_na_ppvth_lt=-0.401 mdn_na_ppvth_rt=-0.013 mdn_na_npvth_up=0.094 mdn_na_npvth_dn=0.297
+mdn_nb_ppvth_lt=-0.184 mdn_nb_ppvth_rt=-0.246 mdn_nb_npvth_up=0.267 mdn_nb_npvth_dn=0.094
+mdn_no_ppvth_lt=-0.055 mdn_no_ppvth_rt=-0.077 mdn_no_npvth_up=0.172 mdn_no_npvth_dn=0.487
**

** 114 PUF stage
xi113 gnd net226 net227 ch_113 net228 net229 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.468 mup_inv_npvth=0.101
+mup_na_ppvth_lt=-0.234 mup_na_ppvth_rt=-0.134 mup_na_npvth_up=0.051 mup_na_npvth_dn=0.660
+mup_nb_ppvth_lt=-0.142 mup_nb_ppvth_rt=-0.980 mup_nb_npvth_up=0.432 mup_nb_npvth_dn=0.328
+mup_no_ppvth_lt=-0.773 mup_no_ppvth_rt=-1.002 mup_no_npvth_up=0.685 mup_no_npvth_dn=0.132

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.308 mdn_inv_npvth=0.349
+mdn_na_ppvth_lt=-0.149 mdn_na_ppvth_rt=-0.521 mdn_na_npvth_up=0.121 mdn_na_npvth_dn=0.036
+mdn_nb_ppvth_lt=-0.346 mdn_nb_ppvth_rt=-0.127 mdn_nb_npvth_up=0.279 mdn_nb_npvth_dn=0.283
+mdn_no_ppvth_lt=-0.430 mdn_no_ppvth_rt=-1.343 mdn_no_npvth_up=0.180 mdn_no_npvth_dn=0.651
**

** 115 PUF stage
xi114 gnd net228 net229 ch_114 net230 net231 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.063 mup_inv_npvth=0.741
+mup_na_ppvth_lt=-0.447 mup_na_ppvth_rt=-0.126 mup_na_npvth_up=0.258 mup_na_npvth_dn=0.003
+mup_nb_ppvth_lt=-0.551 mup_nb_ppvth_rt=-0.229 mup_nb_npvth_up=0.628 mup_nb_npvth_dn=0.319
+mup_no_ppvth_lt=-0.280 mup_no_ppvth_rt=-0.567 mup_no_npvth_up=0.432 mup_no_npvth_dn=0.369

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.659 mdn_inv_npvth=0.103
+mdn_na_ppvth_lt=-0.341 mdn_na_ppvth_rt=-0.964 mdn_na_npvth_up=0.370 mdn_na_npvth_dn=0.033
+mdn_nb_ppvth_lt=-0.112 mdn_nb_ppvth_rt=-0.113 mdn_nb_npvth_up=0.675 mdn_nb_npvth_dn=0.256
+mdn_no_ppvth_lt=-0.164 mdn_no_ppvth_rt=-0.433 mdn_no_npvth_up=0.675 mdn_no_npvth_dn=0.243
**

** 116 PUF stage
xi115 gnd net230 net231 ch_115 net232 net233 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.116 mup_inv_npvth=0.539
+mup_na_ppvth_lt=-0.330 mup_na_ppvth_rt=-0.471 mup_na_npvth_up=0.684 mup_na_npvth_dn=0.234
+mup_nb_ppvth_lt=-0.101 mup_nb_ppvth_rt=-0.070 mup_nb_npvth_up=0.259 mup_nb_npvth_dn=0.339
+mup_no_ppvth_lt=-0.372 mup_no_ppvth_rt=-0.133 mup_no_npvth_up=0.488 mup_no_npvth_dn=0.027

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.068 mdn_inv_npvth=0.332
+mdn_na_ppvth_lt=-0.554 mdn_na_ppvth_rt=-0.291 mdn_na_npvth_up=0.033 mdn_na_npvth_dn=0.088
+mdn_nb_ppvth_lt=-0.578 mdn_nb_ppvth_rt=-0.152 mdn_nb_npvth_up=0.435 mdn_nb_npvth_dn=0.394
+mdn_no_ppvth_lt=-0.001 mdn_no_ppvth_rt=-0.491 mdn_no_npvth_up=0.061 mdn_no_npvth_dn=0.087
**

** 117 PUF stage
xi116 gnd net232 net233 ch_116 net234 net235 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.700 mup_inv_npvth=0.336
+mup_na_ppvth_lt=-0.163 mup_na_ppvth_rt=-0.424 mup_na_npvth_up=0.411 mup_na_npvth_dn=0.256
+mup_nb_ppvth_lt=-0.047 mup_nb_ppvth_rt=-0.331 mup_nb_npvth_up=0.537 mup_nb_npvth_dn=0.035
+mup_no_ppvth_lt=-0.165 mup_no_ppvth_rt=-0.112 mup_no_npvth_up=0.356 mup_no_npvth_dn=0.833

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.045 mdn_inv_npvth=0.495
+mdn_na_ppvth_lt=-0.946 mdn_na_ppvth_rt=-0.227 mdn_na_npvth_up=0.188 mdn_na_npvth_dn=0.342
+mdn_nb_ppvth_lt=-0.344 mdn_nb_ppvth_rt=-0.069 mdn_nb_npvth_up=0.118 mdn_nb_npvth_dn=0.596
+mdn_no_ppvth_lt=-0.685 mdn_no_ppvth_rt=-0.630 mdn_no_npvth_up=0.228 mdn_no_npvth_dn=0.539
**

** 118 PUF stage
xi117 gnd net234 net235 ch_117 net236 net237 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.368 mup_inv_npvth=0.565
+mup_na_ppvth_lt=-0.040 mup_na_ppvth_rt=-0.849 mup_na_npvth_up=0.208 mup_na_npvth_dn=0.386
+mup_nb_ppvth_lt=-0.409 mup_nb_ppvth_rt=-0.393 mup_nb_npvth_up=0.503 mup_nb_npvth_dn=0.310
+mup_no_ppvth_lt=-0.429 mup_no_ppvth_rt=-0.459 mup_no_npvth_up=0.373 mup_no_npvth_dn=0.539

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.348 mdn_inv_npvth=0.204
+mdn_na_ppvth_lt=-0.059 mdn_na_ppvth_rt=-0.639 mdn_na_npvth_up=0.431 mdn_na_npvth_dn=0.252
+mdn_nb_ppvth_lt=-0.663 mdn_nb_ppvth_rt=-0.013 mdn_nb_npvth_up=0.210 mdn_nb_npvth_dn=0.453
+mdn_no_ppvth_lt=-0.099 mdn_no_ppvth_rt=-0.279 mdn_no_npvth_up=0.406 mdn_no_npvth_dn=0.004
**

** 119 PUF stage
xi118 gnd net236 net237 ch_118 net238 net239 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.037 mup_inv_npvth=0.340
+mup_na_ppvth_lt=-0.550 mup_na_ppvth_rt=-0.091 mup_na_npvth_up=0.054 mup_na_npvth_dn=0.171
+mup_nb_ppvth_lt=-0.129 mup_nb_ppvth_rt=-0.658 mup_nb_npvth_up=0.122 mup_nb_npvth_dn=0.381
+mup_no_ppvth_lt=-0.756 mup_no_ppvth_rt=-0.024 mup_no_npvth_up=0.315 mup_no_npvth_dn=0.227

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.044 mdn_inv_npvth=0.395
+mdn_na_ppvth_lt=-0.871 mdn_na_ppvth_rt=-0.215 mdn_na_npvth_up=0.486 mdn_na_npvth_dn=0.132
+mdn_nb_ppvth_lt=-0.119 mdn_nb_ppvth_rt=-0.467 mdn_nb_npvth_up=0.272 mdn_nb_npvth_dn=0.263
+mdn_no_ppvth_lt=-0.086 mdn_no_ppvth_rt=-0.264 mdn_no_npvth_up=0.335 mdn_no_npvth_dn=0.533
**

** 120 PUF stage
xi119 gnd net238 net239 ch_119 net240 net241 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.447 mup_inv_npvth=0.239
+mup_na_ppvth_lt=-0.158 mup_na_ppvth_rt=-0.638 mup_na_npvth_up=0.275 mup_na_npvth_dn=0.535
+mup_nb_ppvth_lt=-0.174 mup_nb_ppvth_rt=-0.648 mup_nb_npvth_up=0.430 mup_nb_npvth_dn=0.285
+mup_no_ppvth_lt=-0.138 mup_no_ppvth_rt=-0.246 mup_no_npvth_up=0.230 mup_no_npvth_dn=0.482

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.150 mdn_inv_npvth=0.901
+mdn_na_ppvth_lt=-0.374 mdn_na_ppvth_rt=-0.327 mdn_na_npvth_up=0.117 mdn_na_npvth_dn=0.662
+mdn_nb_ppvth_lt=-0.310 mdn_nb_ppvth_rt=-0.034 mdn_nb_npvth_up=0.083 mdn_nb_npvth_dn=0.355
+mdn_no_ppvth_lt=-0.029 mdn_no_ppvth_rt=-0.045 mdn_no_npvth_up=0.814 mdn_no_npvth_dn=0.862
**

** 121 PUF stage
xi120 gnd net240 net241 ch_120 net242 net243 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.485 mup_inv_npvth=0.563
+mup_na_ppvth_lt=-0.140 mup_na_ppvth_rt=-0.323 mup_na_npvth_up=0.185 mup_na_npvth_dn=0.478
+mup_nb_ppvth_lt=-0.590 mup_nb_ppvth_rt=-0.457 mup_nb_npvth_up=0.675 mup_nb_npvth_dn=0.705
+mup_no_ppvth_lt=-0.464 mup_no_ppvth_rt=-0.478 mup_no_npvth_up=0.039 mup_no_npvth_dn=0.412

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.443 mdn_inv_npvth=0.159
+mdn_na_ppvth_lt=-0.482 mdn_na_ppvth_rt=-0.158 mdn_na_npvth_up=0.356 mdn_na_npvth_dn=0.164
+mdn_nb_ppvth_lt=-0.204 mdn_nb_ppvth_rt=-0.450 mdn_nb_npvth_up=0.245 mdn_nb_npvth_dn=0.101
+mdn_no_ppvth_lt=-0.856 mdn_no_ppvth_rt=-0.087 mdn_no_npvth_up=0.428 mdn_no_npvth_dn=0.385
**

** 122 PUF stage
xi121 gnd net242 net243 ch_121 net244 net245 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.636 mup_inv_npvth=0.263
+mup_na_ppvth_lt=-0.305 mup_na_ppvth_rt=-0.518 mup_na_npvth_up=0.491 mup_na_npvth_dn=0.388
+mup_nb_ppvth_lt=-0.478 mup_nb_ppvth_rt=-0.153 mup_nb_npvth_up=0.460 mup_nb_npvth_dn=0.360
+mup_no_ppvth_lt=-0.697 mup_no_ppvth_rt=-0.211 mup_no_npvth_up=0.354 mup_no_npvth_dn=0.599

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.173 mdn_inv_npvth=1.033
+mdn_na_ppvth_lt=-0.342 mdn_na_ppvth_rt=-0.328 mdn_na_npvth_up=0.021 mdn_na_npvth_dn=0.819
+mdn_nb_ppvth_lt=-0.335 mdn_nb_ppvth_rt=-0.170 mdn_nb_npvth_up=0.234 mdn_nb_npvth_dn=0.249
+mdn_no_ppvth_lt=-0.520 mdn_no_ppvth_rt=-0.074 mdn_no_npvth_up=0.491 mdn_no_npvth_dn=0.124
**

** 123 PUF stage
xi122 gnd net244 net245 ch_122 net246 net247 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.840 mup_inv_npvth=0.195
+mup_na_ppvth_lt=-0.911 mup_na_ppvth_rt=-0.478 mup_na_npvth_up=0.657 mup_na_npvth_dn=0.929
+mup_nb_ppvth_lt=-1.226 mup_nb_ppvth_rt=-0.277 mup_nb_npvth_up=0.165 mup_nb_npvth_dn=0.009
+mup_no_ppvth_lt=-0.662 mup_no_ppvth_rt=-0.636 mup_no_npvth_up=0.678 mup_no_npvth_dn=0.696

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.845 mdn_inv_npvth=0.580
+mdn_na_ppvth_lt=-0.381 mdn_na_ppvth_rt=-0.708 mdn_na_npvth_up=0.069 mdn_na_npvth_dn=0.877
+mdn_nb_ppvth_lt=-0.650 mdn_nb_ppvth_rt=-0.100 mdn_nb_npvth_up=0.225 mdn_nb_npvth_dn=0.346
+mdn_no_ppvth_lt=-0.607 mdn_no_ppvth_rt=-0.091 mdn_no_npvth_up=0.205 mdn_no_npvth_dn=0.219
**

** 124 PUF stage
xi123 gnd net246 net247 ch_123 net248 net249 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.585 mup_inv_npvth=0.667
+mup_na_ppvth_lt=-0.130 mup_na_ppvth_rt=-0.551 mup_na_npvth_up=0.220 mup_na_npvth_dn=0.350
+mup_nb_ppvth_lt=-0.050 mup_nb_ppvth_rt=-0.719 mup_nb_npvth_up=0.408 mup_nb_npvth_dn=0.127
+mup_no_ppvth_lt=-0.500 mup_no_ppvth_rt=-0.892 mup_no_npvth_up=0.047 mup_no_npvth_dn=0.087

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.568 mdn_inv_npvth=0.468
+mdn_na_ppvth_lt=-0.041 mdn_na_ppvth_rt=-0.714 mdn_na_npvth_up=0.286 mdn_na_npvth_dn=0.663
+mdn_nb_ppvth_lt=-0.405 mdn_nb_ppvth_rt=-0.167 mdn_nb_npvth_up=0.256 mdn_nb_npvth_dn=0.070
+mdn_no_ppvth_lt=-0.132 mdn_no_ppvth_rt=-0.148 mdn_no_npvth_up=0.637 mdn_no_npvth_dn=0.090
**

** 125 PUF stage
xi124 gnd net248 net249 ch_124 net250 net251 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.480 mup_inv_npvth=0.284
+mup_na_ppvth_lt=-0.076 mup_na_ppvth_rt=-0.649 mup_na_npvth_up=0.210 mup_na_npvth_dn=0.388
+mup_nb_ppvth_lt=-0.376 mup_nb_ppvth_rt=-0.020 mup_nb_npvth_up=0.290 mup_nb_npvth_dn=0.062
+mup_no_ppvth_lt=-0.391 mup_no_ppvth_rt=-1.225 mup_no_npvth_up=0.147 mup_no_npvth_dn=0.247

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.024 mdn_inv_npvth=0.164
+mdn_na_ppvth_lt=-0.004 mdn_na_ppvth_rt=-0.502 mdn_na_npvth_up=0.381 mdn_na_npvth_dn=0.118
+mdn_nb_ppvth_lt=-0.021 mdn_nb_ppvth_rt=-0.234 mdn_nb_npvth_up=0.155 mdn_nb_npvth_dn=0.630
+mdn_no_ppvth_lt=-0.064 mdn_no_ppvth_rt=-0.093 mdn_no_npvth_up=0.591 mdn_no_npvth_dn=0.337
**

** 126 PUF stage
xi125 gnd net250 net251 ch_125 net252 net253 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.137 mup_inv_npvth=0.247
+mup_na_ppvth_lt=-0.212 mup_na_ppvth_rt=-0.245 mup_na_npvth_up=1.043 mup_na_npvth_dn=0.060
+mup_nb_ppvth_lt=-0.297 mup_nb_ppvth_rt=-0.574 mup_nb_npvth_up=0.741 mup_nb_npvth_dn=0.713
+mup_no_ppvth_lt=-0.502 mup_no_ppvth_rt=-0.029 mup_no_npvth_up=1.099 mup_no_npvth_dn=0.183

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.291 mdn_inv_npvth=0.074
+mdn_na_ppvth_lt=-0.012 mdn_na_ppvth_rt=-0.490 mdn_na_npvth_up=0.396 mdn_na_npvth_dn=0.694
+mdn_nb_ppvth_lt=-0.020 mdn_nb_ppvth_rt=-0.396 mdn_nb_npvth_up=0.877 mdn_nb_npvth_dn=0.344
+mdn_no_ppvth_lt=-0.232 mdn_no_ppvth_rt=-0.129 mdn_no_npvth_up=0.178 mdn_no_npvth_dn=0.395
**

** 127 PUF stage
xi126 gnd net252 net253 ch_126 net254 net255 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.162 mup_inv_npvth=0.024
+mup_na_ppvth_lt=-0.151 mup_na_ppvth_rt=-0.220 mup_na_npvth_up=0.261 mup_na_npvth_dn=0.330
+mup_nb_ppvth_lt=-0.252 mup_nb_ppvth_rt=-0.011 mup_nb_npvth_up=0.045 mup_nb_npvth_dn=0.206
+mup_no_ppvth_lt=-0.091 mup_no_ppvth_rt=-0.282 mup_no_npvth_up=0.120 mup_no_npvth_dn=0.074

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.274 mdn_inv_npvth=0.154
+mdn_na_ppvth_lt=-0.102 mdn_na_ppvth_rt=-0.128 mdn_na_npvth_up=0.389 mdn_na_npvth_dn=0.040
+mdn_nb_ppvth_lt=-0.543 mdn_nb_ppvth_rt=-0.399 mdn_nb_npvth_up=0.363 mdn_nb_npvth_dn=0.419
+mdn_no_ppvth_lt=-0.540 mdn_no_ppvth_rt=-0.343 mdn_no_npvth_up=0.054 mdn_no_npvth_dn=0.231
**

** 128 PUF stage
xi127 gnd net254 net255 ch_127 net256 net257 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.037 mup_inv_npvth=0.408
+mup_na_ppvth_lt=-0.325 mup_na_ppvth_rt=-0.831 mup_na_npvth_up=0.439 mup_na_npvth_dn=0.334
+mup_nb_ppvth_lt=-0.498 mup_nb_ppvth_rt=-0.169 mup_nb_npvth_up=0.057 mup_nb_npvth_dn=0.260
+mup_no_ppvth_lt=-0.698 mup_no_ppvth_rt=-0.803 mup_no_npvth_up=0.270 mup_no_npvth_dn=0.116

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.384 mdn_inv_npvth=0.023
+mdn_na_ppvth_lt=-0.271 mdn_na_ppvth_rt=-0.897 mdn_na_npvth_up=0.227 mdn_na_npvth_dn=0.876
+mdn_nb_ppvth_lt=-0.081 mdn_nb_ppvth_rt=-0.646 mdn_nb_npvth_up=0.349 mdn_nb_npvth_dn=0.051
+mdn_no_ppvth_lt=-0.505 mdn_no_ppvth_rt=-0.411 mdn_no_npvth_up=0.012 mdn_no_npvth_dn=0.403
**

** SR latch
xi128 gnd q net258 net256 net257 vdd sr_latch
.ends puf_0
** End of subcircuit definition

.end
