** Generated by pufgen.py for: hspiceD
** Generated on: 07/24/18 13:04:59
** Design library name: pufLib
** Design cell name: puf_0
** Design view name: schematic

** Library name: pufLib
** Cell name: puf_0
** View name: schematic
.subckt puf_0 ch_0 ch_1 ch_2 ch_3 ch_4 ch_5 ch_6 ch_7 ch_8 ch_9 ch_10 ch_11 ch_12 ch_13 ch_14 ch_15 ch_16 ch_17 ch_18 ch_19 ch_20 ch_21 ch_22 ch_23 ch_24 ch_25 ch_26 ch_27 ch_28 ch_29 ch_30 ch_31 ch_32 ch_33 ch_34 ch_35 ch_36 ch_37 ch_38 ch_39 ch_40 ch_41 ch_42 ch_43 ch_44 ch_45 ch_46 ch_47 ch_48 ch_49 ch_50 ch_51 ch_52 ch_53 ch_54 ch_55 ch_56 ch_57 ch_58 ch_59 ch_60 ch_61 ch_62 ch_63 ch_64 ch_65 ch_66 ch_67 ch_68 ch_69 ch_70 ch_71 ch_72 ch_73 ch_74 ch_75 ch_76 ch_77 ch_78 ch_79 ch_80 ch_81 ch_82 ch_83 ch_84 ch_85 ch_86 ch_87 ch_88 ch_89 ch_90 ch_91 ch_92 ch_93 ch_94 ch_95 ch_96 ch_97 ch_98 ch_99 ch_100 ch_101 ch_102 ch_103 ch_104 ch_105 ch_106 ch_107 ch_108 ch_109 ch_110 ch_111 ch_112 ch_113 ch_114 ch_115 ch_116 ch_117 ch_118 ch_119 ch_120 ch_121 ch_122 ch_123 ch_124 ch_125 ch_126 ch_127 gnd in_sig q vdd
** 1 PUF stage
xi0 gnd in_sig in_sig ch_0 net2 net3 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.708 mup_inv_npvth=0.431
+mup_na_ppvth_lt=-0.140 mup_na_ppvth_rt=-0.081 mup_na_npvth_up=0.166 mup_na_npvth_dn=0.579
+mup_nb_ppvth_lt=-0.628 mup_nb_ppvth_rt=-0.468 mup_nb_npvth_up=0.455 mup_nb_npvth_dn=0.812
+mup_no_ppvth_lt=-0.527 mup_no_ppvth_rt=-0.002 mup_no_npvth_up=1.109 mup_no_npvth_dn=0.212

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.183 mdn_inv_npvth=0.688
+mdn_na_ppvth_lt=-0.063 mdn_na_ppvth_rt=-0.889 mdn_na_npvth_up=0.589 mdn_na_npvth_dn=0.034
+mdn_nb_ppvth_lt=-0.443 mdn_nb_ppvth_rt=-0.026 mdn_nb_npvth_up=0.051 mdn_nb_npvth_dn=1.008
+mdn_no_ppvth_lt=-0.585 mdn_no_ppvth_rt=-0.144 mdn_no_npvth_up=0.750 mdn_no_npvth_dn=0.154
**

** 2 PUF stage
xi1 gnd net2 net3 ch_1 net4 net5 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.200 mup_inv_npvth=0.513
+mup_na_ppvth_lt=-0.700 mup_na_ppvth_rt=-1.011 mup_na_npvth_up=0.011 mup_na_npvth_dn=0.599
+mup_nb_ppvth_lt=-0.501 mup_nb_ppvth_rt=-0.042 mup_nb_npvth_up=0.467 mup_nb_npvth_dn=0.469
+mup_no_ppvth_lt=-0.339 mup_no_ppvth_rt=-0.675 mup_no_npvth_up=0.142 mup_no_npvth_dn=0.679

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.278 mdn_inv_npvth=0.426
+mdn_na_ppvth_lt=-0.460 mdn_na_ppvth_rt=-0.623 mdn_na_npvth_up=0.343 mdn_na_npvth_dn=0.600
+mdn_nb_ppvth_lt=-0.313 mdn_nb_ppvth_rt=-0.071 mdn_nb_npvth_up=0.696 mdn_nb_npvth_dn=0.167
+mdn_no_ppvth_lt=-0.736 mdn_no_ppvth_rt=-0.628 mdn_no_npvth_up=0.232 mdn_no_npvth_dn=0.203
**

** 3 PUF stage
xi2 gnd net4 net5 ch_2 net6 net7 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.634 mup_inv_npvth=0.687
+mup_na_ppvth_lt=-0.890 mup_na_ppvth_rt=-0.414 mup_na_npvth_up=0.091 mup_na_npvth_dn=0.172
+mup_nb_ppvth_lt=-0.181 mup_nb_ppvth_rt=-0.248 mup_nb_npvth_up=0.298 mup_nb_npvth_dn=0.299
+mup_no_ppvth_lt=-1.012 mup_no_ppvth_rt=-0.363 mup_no_npvth_up=0.339 mup_no_npvth_dn=0.021

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.322 mdn_inv_npvth=0.106
+mdn_na_ppvth_lt=-0.356 mdn_na_ppvth_rt=-0.115 mdn_na_npvth_up=0.772 mdn_na_npvth_dn=0.391
+mdn_nb_ppvth_lt=-0.248 mdn_nb_ppvth_rt=-0.261 mdn_nb_npvth_up=0.257 mdn_nb_npvth_dn=0.727
+mdn_no_ppvth_lt=-0.181 mdn_no_ppvth_rt=-0.590 mdn_no_npvth_up=0.387 mdn_no_npvth_dn=0.032
**

** 4 PUF stage
xi3 gnd net6 net7 ch_3 net8 net9 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.855 mup_inv_npvth=0.530
+mup_na_ppvth_lt=-0.528 mup_na_ppvth_rt=-0.414 mup_na_npvth_up=0.964 mup_na_npvth_dn=0.399
+mup_nb_ppvth_lt=-0.217 mup_nb_ppvth_rt=-0.050 mup_nb_npvth_up=0.467 mup_nb_npvth_dn=0.691
+mup_no_ppvth_lt=-0.450 mup_no_ppvth_rt=-0.146 mup_no_npvth_up=0.215 mup_no_npvth_dn=0.674

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.052 mdn_inv_npvth=0.088
+mdn_na_ppvth_lt=-0.186 mdn_na_ppvth_rt=-1.221 mdn_na_npvth_up=0.109 mdn_na_npvth_dn=0.345
+mdn_nb_ppvth_lt=-0.844 mdn_nb_ppvth_rt=-0.459 mdn_nb_npvth_up=0.275 mdn_nb_npvth_dn=0.235
+mdn_no_ppvth_lt=-0.318 mdn_no_ppvth_rt=-0.196 mdn_no_npvth_up=0.319 mdn_no_npvth_dn=0.410
**

** 5 PUF stage
xi4 gnd net8 net9 ch_4 net10 net11 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.406 mup_inv_npvth=0.349
+mup_na_ppvth_lt=-0.701 mup_na_ppvth_rt=-0.048 mup_na_npvth_up=0.065 mup_na_npvth_dn=0.577
+mup_nb_ppvth_lt=-0.116 mup_nb_ppvth_rt=-0.446 mup_nb_npvth_up=0.469 mup_nb_npvth_dn=0.159
+mup_no_ppvth_lt=-0.123 mup_no_ppvth_rt=-0.349 mup_no_npvth_up=0.142 mup_no_npvth_dn=0.131

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.540 mdn_inv_npvth=0.263
+mdn_na_ppvth_lt=-0.354 mdn_na_ppvth_rt=-0.318 mdn_na_npvth_up=0.313 mdn_na_npvth_dn=0.037
+mdn_nb_ppvth_lt=-0.413 mdn_nb_ppvth_rt=-0.284 mdn_nb_npvth_up=0.523 mdn_nb_npvth_dn=0.332
+mdn_no_ppvth_lt=-0.295 mdn_no_ppvth_rt=-0.039 mdn_no_npvth_up=0.442 mdn_no_npvth_dn=0.369
**

** 6 PUF stage
xi5 gnd net10 net11 ch_5 net12 net13 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.189 mup_inv_npvth=0.853
+mup_na_ppvth_lt=-0.170 mup_na_ppvth_rt=-0.864 mup_na_npvth_up=0.150 mup_na_npvth_dn=0.805
+mup_nb_ppvth_lt=-0.176 mup_nb_ppvth_rt=-0.161 mup_nb_npvth_up=0.044 mup_nb_npvth_dn=0.110
+mup_no_ppvth_lt=-0.025 mup_no_ppvth_rt=-0.201 mup_no_npvth_up=0.460 mup_no_npvth_dn=0.531

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.680 mdn_inv_npvth=0.031
+mdn_na_ppvth_lt=-0.269 mdn_na_ppvth_rt=-0.035 mdn_na_npvth_up=0.079 mdn_na_npvth_dn=1.166
+mdn_nb_ppvth_lt=-0.056 mdn_nb_ppvth_rt=-0.371 mdn_nb_npvth_up=0.736 mdn_nb_npvth_dn=0.608
+mdn_no_ppvth_lt=-0.603 mdn_no_ppvth_rt=-0.124 mdn_no_npvth_up=0.183 mdn_no_npvth_dn=0.518
**

** 7 PUF stage
xi6 gnd net12 net13 ch_6 net14 net15 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.241 mup_inv_npvth=0.035
+mup_na_ppvth_lt=-0.237 mup_na_ppvth_rt=-0.565 mup_na_npvth_up=0.424 mup_na_npvth_dn=0.019
+mup_nb_ppvth_lt=-0.518 mup_nb_ppvth_rt=-0.360 mup_nb_npvth_up=0.883 mup_nb_npvth_dn=0.758
+mup_no_ppvth_lt=-0.644 mup_no_ppvth_rt=-0.220 mup_no_npvth_up=0.476 mup_no_npvth_dn=0.364

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.152 mdn_inv_npvth=0.406
+mdn_na_ppvth_lt=-0.341 mdn_na_ppvth_rt=-0.239 mdn_na_npvth_up=0.428 mdn_na_npvth_dn=0.299
+mdn_nb_ppvth_lt=-0.788 mdn_nb_ppvth_rt=-0.664 mdn_nb_npvth_up=0.462 mdn_nb_npvth_dn=0.347
+mdn_no_ppvth_lt=-0.453 mdn_no_ppvth_rt=-0.241 mdn_no_npvth_up=0.353 mdn_no_npvth_dn=0.216
**

** 8 PUF stage
xi7 gnd net14 net15 ch_7 net16 net17 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.032 mup_inv_npvth=0.400
+mup_na_ppvth_lt=-0.085 mup_na_ppvth_rt=-0.649 mup_na_npvth_up=0.540 mup_na_npvth_dn=0.131
+mup_nb_ppvth_lt=-0.082 mup_nb_ppvth_rt=-0.157 mup_nb_npvth_up=0.115 mup_nb_npvth_dn=0.648
+mup_no_ppvth_lt=-0.155 mup_no_ppvth_rt=-0.572 mup_no_npvth_up=0.116 mup_no_npvth_dn=0.167

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.978 mdn_inv_npvth=0.428
+mdn_na_ppvth_lt=-1.096 mdn_na_ppvth_rt=-0.366 mdn_na_npvth_up=0.510 mdn_na_npvth_dn=0.681
+mdn_nb_ppvth_lt=-0.091 mdn_nb_ppvth_rt=-0.273 mdn_nb_npvth_up=0.289 mdn_nb_npvth_dn=0.605
+mdn_no_ppvth_lt=-0.128 mdn_no_ppvth_rt=-0.021 mdn_no_npvth_up=0.264 mdn_no_npvth_dn=0.424
**

** 9 PUF stage
xi8 gnd net16 net17 ch_8 net18 net19 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.086 mup_inv_npvth=0.861
+mup_na_ppvth_lt=-0.135 mup_na_ppvth_rt=-0.093 mup_na_npvth_up=0.501 mup_na_npvth_dn=0.427
+mup_nb_ppvth_lt=-0.253 mup_nb_ppvth_rt=-0.086 mup_nb_npvth_up=0.047 mup_nb_npvth_dn=0.710
+mup_no_ppvth_lt=-0.019 mup_no_ppvth_rt=-0.780 mup_no_npvth_up=0.111 mup_no_npvth_dn=0.813

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.023 mdn_inv_npvth=0.618
+mdn_na_ppvth_lt=-0.045 mdn_na_ppvth_rt=-0.311 mdn_na_npvth_up=0.576 mdn_na_npvth_dn=0.875
+mdn_nb_ppvth_lt=-0.763 mdn_nb_ppvth_rt=-0.607 mdn_nb_npvth_up=0.085 mdn_nb_npvth_dn=0.112
+mdn_no_ppvth_lt=-0.663 mdn_no_ppvth_rt=-0.033 mdn_no_npvth_up=0.699 mdn_no_npvth_dn=0.389
**

** 10 PUF stage
xi9 gnd net18 net19 ch_9 net20 net21 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.098 mup_inv_npvth=0.628
+mup_na_ppvth_lt=-0.668 mup_na_ppvth_rt=-0.128 mup_na_npvth_up=0.477 mup_na_npvth_dn=0.115
+mup_nb_ppvth_lt=-0.038 mup_nb_ppvth_rt=-0.166 mup_nb_npvth_up=0.868 mup_nb_npvth_dn=0.432
+mup_no_ppvth_lt=-0.214 mup_no_ppvth_rt=-0.317 mup_no_npvth_up=0.201 mup_no_npvth_dn=0.339

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.151 mdn_inv_npvth=0.012
+mdn_na_ppvth_lt=-0.130 mdn_na_ppvth_rt=-0.129 mdn_na_npvth_up=0.422 mdn_na_npvth_dn=0.248
+mdn_nb_ppvth_lt=-0.237 mdn_nb_ppvth_rt=-0.040 mdn_nb_npvth_up=0.305 mdn_nb_npvth_dn=0.484
+mdn_no_ppvth_lt=-0.126 mdn_no_ppvth_rt=-0.298 mdn_no_npvth_up=0.563 mdn_no_npvth_dn=0.349
**

** 11 PUF stage
xi10 gnd net20 net21 ch_10 net22 net23 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.234 mup_inv_npvth=0.131
+mup_na_ppvth_lt=-0.266 mup_na_ppvth_rt=-0.098 mup_na_npvth_up=0.405 mup_na_npvth_dn=0.438
+mup_nb_ppvth_lt=-0.579 mup_nb_ppvth_rt=-0.672 mup_nb_npvth_up=0.070 mup_nb_npvth_dn=0.684
+mup_no_ppvth_lt=-0.291 mup_no_ppvth_rt=-0.528 mup_no_npvth_up=0.275 mup_no_npvth_dn=0.599

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.228 mdn_inv_npvth=0.596
+mdn_na_ppvth_lt=-0.493 mdn_na_ppvth_rt=-0.174 mdn_na_npvth_up=0.450 mdn_na_npvth_dn=0.329
+mdn_nb_ppvth_lt=-0.036 mdn_nb_ppvth_rt=-0.394 mdn_nb_npvth_up=0.519 mdn_nb_npvth_dn=0.426
+mdn_no_ppvth_lt=-0.089 mdn_no_ppvth_rt=-0.226 mdn_no_npvth_up=0.385 mdn_no_npvth_dn=0.650
**

** 12 PUF stage
xi11 gnd net22 net23 ch_11 net24 net25 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.090 mup_inv_npvth=0.773
+mup_na_ppvth_lt=-0.099 mup_na_ppvth_rt=-0.397 mup_na_npvth_up=0.420 mup_na_npvth_dn=0.217
+mup_nb_ppvth_lt=-0.301 mup_nb_ppvth_rt=-0.174 mup_nb_npvth_up=0.252 mup_nb_npvth_dn=0.357
+mup_no_ppvth_lt=-0.023 mup_no_ppvth_rt=-0.125 mup_no_npvth_up=0.259 mup_no_npvth_dn=0.387

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.344 mdn_inv_npvth=0.765
+mdn_na_ppvth_lt=-0.086 mdn_na_ppvth_rt=-0.190 mdn_na_npvth_up=0.598 mdn_na_npvth_dn=0.496
+mdn_nb_ppvth_lt=-0.441 mdn_nb_ppvth_rt=-0.342 mdn_nb_npvth_up=0.651 mdn_nb_npvth_dn=0.778
+mdn_no_ppvth_lt=-0.325 mdn_no_ppvth_rt=-0.137 mdn_no_npvth_up=0.137 mdn_no_npvth_dn=0.082
**

** 13 PUF stage
xi12 gnd net24 net25 ch_12 net26 net27 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.049 mup_inv_npvth=0.448
+mup_na_ppvth_lt=-0.121 mup_na_ppvth_rt=-0.413 mup_na_npvth_up=0.104 mup_na_npvth_dn=0.356
+mup_nb_ppvth_lt=-0.113 mup_nb_ppvth_rt=-0.328 mup_nb_npvth_up=0.126 mup_nb_npvth_dn=0.444
+mup_no_ppvth_lt=-0.328 mup_no_ppvth_rt=-0.083 mup_no_npvth_up=0.354 mup_no_npvth_dn=0.473

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.348 mdn_inv_npvth=0.053
+mdn_na_ppvth_lt=-0.045 mdn_na_ppvth_rt=-0.996 mdn_na_npvth_up=0.231 mdn_na_npvth_dn=0.123
+mdn_nb_ppvth_lt=-0.132 mdn_nb_ppvth_rt=-0.176 mdn_nb_npvth_up=0.154 mdn_nb_npvth_dn=0.372
+mdn_no_ppvth_lt=-0.554 mdn_no_ppvth_rt=-0.522 mdn_no_npvth_up=0.092 mdn_no_npvth_dn=0.206
**

** 14 PUF stage
xi13 gnd net26 net27 ch_13 net28 net29 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.275 mup_inv_npvth=0.069
+mup_na_ppvth_lt=-0.900 mup_na_ppvth_rt=-0.092 mup_na_npvth_up=0.299 mup_na_npvth_dn=0.695
+mup_nb_ppvth_lt=-0.473 mup_nb_ppvth_rt=-0.796 mup_nb_npvth_up=0.218 mup_nb_npvth_dn=0.540
+mup_no_ppvth_lt=-0.322 mup_no_ppvth_rt=-0.130 mup_no_npvth_up=0.549 mup_no_npvth_dn=0.234

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.511 mdn_inv_npvth=0.847
+mdn_na_ppvth_lt=-0.167 mdn_na_ppvth_rt=-0.346 mdn_na_npvth_up=0.658 mdn_na_npvth_dn=0.107
+mdn_nb_ppvth_lt=-0.467 mdn_nb_ppvth_rt=-0.243 mdn_nb_npvth_up=0.674 mdn_nb_npvth_dn=0.487
+mdn_no_ppvth_lt=-0.404 mdn_no_ppvth_rt=-0.098 mdn_no_npvth_up=0.268 mdn_no_npvth_dn=0.949
**

** 15 PUF stage
xi14 gnd net28 net29 ch_14 net30 net31 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-1.216 mup_inv_npvth=0.383
+mup_na_ppvth_lt=-0.532 mup_na_ppvth_rt=-0.488 mup_na_npvth_up=0.124 mup_na_npvth_dn=0.571
+mup_nb_ppvth_lt=-0.256 mup_nb_ppvth_rt=-0.395 mup_nb_npvth_up=0.344 mup_nb_npvth_dn=0.319
+mup_no_ppvth_lt=-0.406 mup_no_ppvth_rt=-0.172 mup_no_npvth_up=0.492 mup_no_npvth_dn=0.114

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.003 mdn_inv_npvth=0.360
+mdn_na_ppvth_lt=-0.296 mdn_na_ppvth_rt=-0.057 mdn_na_npvth_up=0.569 mdn_na_npvth_dn=0.178
+mdn_nb_ppvth_lt=-0.449 mdn_nb_ppvth_rt=-0.650 mdn_nb_npvth_up=0.458 mdn_nb_npvth_dn=0.423
+mdn_no_ppvth_lt=-0.201 mdn_no_ppvth_rt=-0.863 mdn_no_npvth_up=0.205 mdn_no_npvth_dn=0.075
**

** 16 PUF stage
xi15 gnd net30 net31 ch_15 net32 net33 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.845 mup_inv_npvth=0.083
+mup_na_ppvth_lt=-0.114 mup_na_ppvth_rt=-0.198 mup_na_npvth_up=0.023 mup_na_npvth_dn=0.305
+mup_nb_ppvth_lt=-0.588 mup_nb_ppvth_rt=-0.586 mup_nb_npvth_up=0.447 mup_nb_npvth_dn=0.327
+mup_no_ppvth_lt=-0.193 mup_no_ppvth_rt=-0.352 mup_no_npvth_up=0.431 mup_no_npvth_dn=0.357

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.073 mdn_inv_npvth=0.182
+mdn_na_ppvth_lt=-0.268 mdn_na_ppvth_rt=-0.771 mdn_na_npvth_up=0.041 mdn_na_npvth_dn=0.536
+mdn_nb_ppvth_lt=-0.154 mdn_nb_ppvth_rt=-0.644 mdn_nb_npvth_up=0.885 mdn_nb_npvth_dn=0.150
+mdn_no_ppvth_lt=-0.458 mdn_no_ppvth_rt=-0.561 mdn_no_npvth_up=0.267 mdn_no_npvth_dn=0.022
**

** 17 PUF stage
xi16 gnd net32 net33 ch_16 net34 net35 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.329 mup_inv_npvth=0.203
+mup_na_ppvth_lt=-0.275 mup_na_ppvth_rt=-0.039 mup_na_npvth_up=0.081 mup_na_npvth_dn=0.510
+mup_nb_ppvth_lt=-0.142 mup_nb_ppvth_rt=-0.583 mup_nb_npvth_up=0.171 mup_nb_npvth_dn=0.578
+mup_no_ppvth_lt=-0.877 mup_no_ppvth_rt=-0.228 mup_no_npvth_up=0.024 mup_no_npvth_dn=0.623

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.740 mdn_inv_npvth=0.108
+mdn_na_ppvth_lt=-0.126 mdn_na_ppvth_rt=-0.342 mdn_na_npvth_up=0.517 mdn_na_npvth_dn=0.118
+mdn_nb_ppvth_lt=-0.531 mdn_nb_ppvth_rt=-0.332 mdn_nb_npvth_up=0.528 mdn_nb_npvth_dn=0.167
+mdn_no_ppvth_lt=-0.182 mdn_no_ppvth_rt=-0.479 mdn_no_npvth_up=0.072 mdn_no_npvth_dn=0.544
**

** 18 PUF stage
xi17 gnd net34 net35 ch_17 net36 net37 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.240 mup_inv_npvth=0.402
+mup_na_ppvth_lt=-0.056 mup_na_ppvth_rt=-0.325 mup_na_npvth_up=0.300 mup_na_npvth_dn=0.238
+mup_nb_ppvth_lt=-0.236 mup_nb_ppvth_rt=-0.929 mup_nb_npvth_up=0.694 mup_nb_npvth_dn=0.131
+mup_no_ppvth_lt=-0.236 mup_no_ppvth_rt=-0.686 mup_no_npvth_up=0.134 mup_no_npvth_dn=0.710

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.370 mdn_inv_npvth=0.047
+mdn_na_ppvth_lt=-0.864 mdn_na_ppvth_rt=-0.173 mdn_na_npvth_up=0.812 mdn_na_npvth_dn=0.308
+mdn_nb_ppvth_lt=-0.385 mdn_nb_ppvth_rt=-0.797 mdn_nb_npvth_up=0.890 mdn_nb_npvth_dn=0.174
+mdn_no_ppvth_lt=-0.142 mdn_no_ppvth_rt=-0.431 mdn_no_npvth_up=0.304 mdn_no_npvth_dn=0.697
**

** 19 PUF stage
xi18 gnd net36 net37 ch_18 net38 net39 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.287 mup_inv_npvth=0.194
+mup_na_ppvth_lt=-0.108 mup_na_ppvth_rt=-0.310 mup_na_npvth_up=0.155 mup_na_npvth_dn=0.057
+mup_nb_ppvth_lt=-0.105 mup_nb_ppvth_rt=-0.732 mup_nb_npvth_up=0.478 mup_nb_npvth_dn=0.464
+mup_no_ppvth_lt=-0.213 mup_no_ppvth_rt=-0.525 mup_no_npvth_up=0.556 mup_no_npvth_dn=0.087

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.076 mdn_inv_npvth=0.208
+mdn_na_ppvth_lt=-0.479 mdn_na_ppvth_rt=-0.100 mdn_na_npvth_up=0.672 mdn_na_npvth_dn=0.740
+mdn_nb_ppvth_lt=-0.128 mdn_nb_ppvth_rt=-0.249 mdn_nb_npvth_up=1.226 mdn_nb_npvth_dn=0.559
+mdn_no_ppvth_lt=-0.221 mdn_no_ppvth_rt=-0.407 mdn_no_npvth_up=0.223 mdn_no_npvth_dn=0.477
**

** 20 PUF stage
xi19 gnd net38 net39 ch_19 net40 net41 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.040 mup_inv_npvth=0.443
+mup_na_ppvth_lt=-0.114 mup_na_ppvth_rt=-0.095 mup_na_npvth_up=0.688 mup_na_npvth_dn=0.145
+mup_nb_ppvth_lt=-0.464 mup_nb_ppvth_rt=-0.111 mup_nb_npvth_up=0.389 mup_nb_npvth_dn=0.341
+mup_no_ppvth_lt=-0.251 mup_no_ppvth_rt=-0.241 mup_no_npvth_up=0.302 mup_no_npvth_dn=0.243

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.339 mdn_inv_npvth=0.347
+mdn_na_ppvth_lt=-0.141 mdn_na_ppvth_rt=-0.740 mdn_na_npvth_up=0.025 mdn_na_npvth_dn=0.225
+mdn_nb_ppvth_lt=-0.366 mdn_nb_ppvth_rt=-1.071 mdn_nb_npvth_up=0.142 mdn_nb_npvth_dn=0.298
+mdn_no_ppvth_lt=-0.281 mdn_no_ppvth_rt=-0.184 mdn_no_npvth_up=0.702 mdn_no_npvth_dn=0.641
**

** 21 PUF stage
xi20 gnd net40 net41 ch_20 net42 net43 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.412 mup_inv_npvth=0.407
+mup_na_ppvth_lt=-0.200 mup_na_ppvth_rt=-0.395 mup_na_npvth_up=0.301 mup_na_npvth_dn=0.103
+mup_nb_ppvth_lt=-0.346 mup_nb_ppvth_rt=-0.386 mup_nb_npvth_up=0.255 mup_nb_npvth_dn=0.486
+mup_no_ppvth_lt=-0.345 mup_no_ppvth_rt=-0.154 mup_no_npvth_up=0.383 mup_no_npvth_dn=0.370

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.300 mdn_inv_npvth=0.124
+mdn_na_ppvth_lt=-0.196 mdn_na_ppvth_rt=-0.022 mdn_na_npvth_up=0.285 mdn_na_npvth_dn=0.652
+mdn_nb_ppvth_lt=-0.396 mdn_nb_ppvth_rt=-0.020 mdn_nb_npvth_up=0.023 mdn_nb_npvth_dn=0.718
+mdn_no_ppvth_lt=-0.274 mdn_no_ppvth_rt=-0.405 mdn_no_npvth_up=0.329 mdn_no_npvth_dn=0.153
**

** 22 PUF stage
xi21 gnd net42 net43 ch_21 net44 net45 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.199 mup_inv_npvth=0.000
+mup_na_ppvth_lt=-0.092 mup_na_ppvth_rt=-0.580 mup_na_npvth_up=0.095 mup_na_npvth_dn=0.207
+mup_nb_ppvth_lt=-0.522 mup_nb_ppvth_rt=-0.068 mup_nb_npvth_up=0.620 mup_nb_npvth_dn=0.832
+mup_no_ppvth_lt=-0.560 mup_no_ppvth_rt=-0.029 mup_no_npvth_up=0.314 mup_no_npvth_dn=0.493

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.335 mdn_inv_npvth=0.341
+mdn_na_ppvth_lt=-0.513 mdn_na_ppvth_rt=-0.062 mdn_na_npvth_up=0.489 mdn_na_npvth_dn=0.381
+mdn_nb_ppvth_lt=-0.424 mdn_nb_ppvth_rt=-0.197 mdn_nb_npvth_up=0.196 mdn_nb_npvth_dn=0.182
+mdn_no_ppvth_lt=-0.244 mdn_no_ppvth_rt=-0.509 mdn_no_npvth_up=0.480 mdn_no_npvth_dn=0.571
**

** 23 PUF stage
xi22 gnd net44 net45 ch_22 net46 net47 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.487 mup_inv_npvth=0.432
+mup_na_ppvth_lt=-0.811 mup_na_ppvth_rt=-0.488 mup_na_npvth_up=0.330 mup_na_npvth_dn=0.401
+mup_nb_ppvth_lt=-0.079 mup_nb_ppvth_rt=-0.017 mup_nb_npvth_up=0.340 mup_nb_npvth_dn=0.667
+mup_no_ppvth_lt=-0.648 mup_no_ppvth_rt=-0.073 mup_no_npvth_up=0.004 mup_no_npvth_dn=0.534

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.176 mdn_inv_npvth=0.139
+mdn_na_ppvth_lt=-0.151 mdn_na_ppvth_rt=-0.083 mdn_na_npvth_up=0.138 mdn_na_npvth_dn=0.768
+mdn_nb_ppvth_lt=-0.856 mdn_nb_ppvth_rt=-0.799 mdn_nb_npvth_up=0.359 mdn_nb_npvth_dn=0.259
+mdn_no_ppvth_lt=-0.011 mdn_no_ppvth_rt=-0.417 mdn_no_npvth_up=0.560 mdn_no_npvth_dn=0.311
**

** 24 PUF stage
xi23 gnd net46 net47 ch_23 net48 net49 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.456 mup_inv_npvth=0.439
+mup_na_ppvth_lt=-0.697 mup_na_ppvth_rt=-0.351 mup_na_npvth_up=0.590 mup_na_npvth_dn=0.177
+mup_nb_ppvth_lt=-0.630 mup_nb_ppvth_rt=-0.630 mup_nb_npvth_up=0.332 mup_nb_npvth_dn=0.175
+mup_no_ppvth_lt=-0.209 mup_no_ppvth_rt=-0.246 mup_no_npvth_up=0.316 mup_no_npvth_dn=0.189

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.660 mdn_inv_npvth=0.441
+mdn_na_ppvth_lt=-0.016 mdn_na_ppvth_rt=-0.551 mdn_na_npvth_up=0.186 mdn_na_npvth_dn=0.209
+mdn_nb_ppvth_lt=-0.026 mdn_nb_ppvth_rt=-0.120 mdn_nb_npvth_up=0.239 mdn_nb_npvth_dn=0.122
+mdn_no_ppvth_lt=-0.311 mdn_no_ppvth_rt=-1.158 mdn_no_npvth_up=0.351 mdn_no_npvth_dn=0.066
**

** 25 PUF stage
xi24 gnd net48 net49 ch_24 net50 net51 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.356 mup_inv_npvth=0.572
+mup_na_ppvth_lt=-0.642 mup_na_ppvth_rt=-0.153 mup_na_npvth_up=0.444 mup_na_npvth_dn=0.411
+mup_nb_ppvth_lt=-0.784 mup_nb_ppvth_rt=-0.520 mup_nb_npvth_up=0.139 mup_nb_npvth_dn=0.348
+mup_no_ppvth_lt=-0.255 mup_no_ppvth_rt=-0.605 mup_no_npvth_up=0.383 mup_no_npvth_dn=0.528

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.099 mdn_inv_npvth=0.506
+mdn_na_ppvth_lt=-0.146 mdn_na_ppvth_rt=-0.372 mdn_na_npvth_up=0.433 mdn_na_npvth_dn=0.367
+mdn_nb_ppvth_lt=-0.120 mdn_nb_ppvth_rt=-0.242 mdn_nb_npvth_up=0.388 mdn_nb_npvth_dn=0.277
+mdn_no_ppvth_lt=-0.141 mdn_no_ppvth_rt=-0.193 mdn_no_npvth_up=0.153 mdn_no_npvth_dn=0.758
**

** 26 PUF stage
xi25 gnd net50 net51 ch_25 net52 net53 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-1.076 mup_inv_npvth=0.569
+mup_na_ppvth_lt=-0.512 mup_na_ppvth_rt=-0.238 mup_na_npvth_up=0.350 mup_na_npvth_dn=0.537
+mup_nb_ppvth_lt=-0.786 mup_nb_ppvth_rt=-0.537 mup_nb_npvth_up=0.375 mup_nb_npvth_dn=0.509
+mup_no_ppvth_lt=-0.850 mup_no_ppvth_rt=-0.207 mup_no_npvth_up=0.065 mup_no_npvth_dn=0.232

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.013 mdn_inv_npvth=0.256
+mdn_na_ppvth_lt=-0.591 mdn_na_ppvth_rt=-0.430 mdn_na_npvth_up=0.322 mdn_na_npvth_dn=0.272
+mdn_nb_ppvth_lt=-0.358 mdn_nb_ppvth_rt=-0.021 mdn_nb_npvth_up=0.292 mdn_nb_npvth_dn=0.589
+mdn_no_ppvth_lt=-0.224 mdn_no_ppvth_rt=-0.025 mdn_no_npvth_up=0.088 mdn_no_npvth_dn=0.448
**

** 27 PUF stage
xi26 gnd net52 net53 ch_26 net54 net55 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.410 mup_inv_npvth=0.021
+mup_na_ppvth_lt=-1.171 mup_na_ppvth_rt=-0.869 mup_na_npvth_up=0.492 mup_na_npvth_dn=0.042
+mup_nb_ppvth_lt=-0.679 mup_nb_ppvth_rt=-0.374 mup_nb_npvth_up=0.676 mup_nb_npvth_dn=0.803
+mup_no_ppvth_lt=-0.257 mup_no_ppvth_rt=-0.019 mup_no_npvth_up=0.204 mup_no_npvth_dn=0.569

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.440 mdn_inv_npvth=0.013
+mdn_na_ppvth_lt=-0.312 mdn_na_ppvth_rt=-0.006 mdn_na_npvth_up=0.334 mdn_na_npvth_dn=0.233
+mdn_nb_ppvth_lt=-0.123 mdn_nb_ppvth_rt=-0.615 mdn_nb_npvth_up=0.208 mdn_nb_npvth_dn=0.388
+mdn_no_ppvth_lt=-0.271 mdn_no_ppvth_rt=-0.800 mdn_no_npvth_up=0.563 mdn_no_npvth_dn=0.530
**

** 28 PUF stage
xi27 gnd net54 net55 ch_27 net56 net57 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.357 mup_inv_npvth=0.464
+mup_na_ppvth_lt=-0.068 mup_na_ppvth_rt=-0.733 mup_na_npvth_up=0.106 mup_na_npvth_dn=0.372
+mup_nb_ppvth_lt=-0.435 mup_nb_ppvth_rt=-0.344 mup_nb_npvth_up=0.487 mup_nb_npvth_dn=0.434
+mup_no_ppvth_lt=-0.281 mup_no_ppvth_rt=-0.223 mup_no_npvth_up=0.537 mup_no_npvth_dn=0.309

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.142 mdn_inv_npvth=0.699
+mdn_na_ppvth_lt=-0.590 mdn_na_ppvth_rt=-0.766 mdn_na_npvth_up=0.305 mdn_na_npvth_dn=0.592
+mdn_nb_ppvth_lt=-0.115 mdn_nb_ppvth_rt=-0.660 mdn_nb_npvth_up=0.462 mdn_nb_npvth_dn=0.292
+mdn_no_ppvth_lt=-0.615 mdn_no_ppvth_rt=-0.048 mdn_no_npvth_up=0.273 mdn_no_npvth_dn=0.616
**

** 29 PUF stage
xi28 gnd net56 net57 ch_28 net58 net59 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.161 mup_inv_npvth=0.333
+mup_na_ppvth_lt=-0.215 mup_na_ppvth_rt=-0.739 mup_na_npvth_up=0.386 mup_na_npvth_dn=0.197
+mup_nb_ppvth_lt=-0.061 mup_nb_ppvth_rt=-0.198 mup_nb_npvth_up=0.702 mup_nb_npvth_dn=0.392
+mup_no_ppvth_lt=-0.746 mup_no_ppvth_rt=-0.069 mup_no_npvth_up=0.082 mup_no_npvth_dn=0.307

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.516 mdn_inv_npvth=0.336
+mdn_na_ppvth_lt=-0.597 mdn_na_ppvth_rt=-1.000 mdn_na_npvth_up=0.216 mdn_na_npvth_dn=0.002
+mdn_nb_ppvth_lt=-0.006 mdn_nb_ppvth_rt=-0.123 mdn_nb_npvth_up=0.156 mdn_nb_npvth_dn=0.479
+mdn_no_ppvth_lt=-0.568 mdn_no_ppvth_rt=-0.466 mdn_no_npvth_up=0.575 mdn_no_npvth_dn=0.742
**

** 30 PUF stage
xi29 gnd net58 net59 ch_29 net60 net61 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.790 mup_inv_npvth=0.269
+mup_na_ppvth_lt=-0.203 mup_na_ppvth_rt=-0.194 mup_na_npvth_up=0.506 mup_na_npvth_dn=0.416
+mup_nb_ppvth_lt=-0.258 mup_nb_ppvth_rt=-0.403 mup_nb_npvth_up=0.366 mup_nb_npvth_dn=0.055
+mup_no_ppvth_lt=-0.528 mup_no_ppvth_rt=-0.472 mup_no_npvth_up=0.434 mup_no_npvth_dn=0.297

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.351 mdn_inv_npvth=0.300
+mdn_na_ppvth_lt=-0.588 mdn_na_ppvth_rt=-0.284 mdn_na_npvth_up=0.095 mdn_na_npvth_dn=0.561
+mdn_nb_ppvth_lt=-0.418 mdn_nb_ppvth_rt=-0.669 mdn_nb_npvth_up=0.043 mdn_nb_npvth_dn=0.834
+mdn_no_ppvth_lt=-0.279 mdn_no_ppvth_rt=-0.252 mdn_no_npvth_up=0.249 mdn_no_npvth_dn=0.421
**

** 31 PUF stage
xi30 gnd net60 net61 ch_30 net62 net63 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.037 mup_inv_npvth=0.254
+mup_na_ppvth_lt=-0.176 mup_na_ppvth_rt=-0.305 mup_na_npvth_up=0.547 mup_na_npvth_dn=0.522
+mup_nb_ppvth_lt=-0.154 mup_nb_ppvth_rt=-0.074 mup_nb_npvth_up=0.614 mup_nb_npvth_dn=0.180
+mup_no_ppvth_lt=-0.620 mup_no_ppvth_rt=-0.642 mup_no_npvth_up=0.528 mup_no_npvth_dn=0.585

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.152 mdn_inv_npvth=0.142
+mdn_na_ppvth_lt=-0.713 mdn_na_ppvth_rt=-0.694 mdn_na_npvth_up=0.456 mdn_na_npvth_dn=0.093
+mdn_nb_ppvth_lt=-0.015 mdn_nb_ppvth_rt=-0.172 mdn_nb_npvth_up=0.240 mdn_nb_npvth_dn=0.471
+mdn_no_ppvth_lt=-0.863 mdn_no_ppvth_rt=-0.351 mdn_no_npvth_up=0.493 mdn_no_npvth_dn=0.354
**

** 32 PUF stage
xi31 gnd net62 net63 ch_31 net64 net65 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.420 mup_inv_npvth=0.252
+mup_na_ppvth_lt=-0.132 mup_na_ppvth_rt=-0.922 mup_na_npvth_up=0.077 mup_na_npvth_dn=0.149
+mup_nb_ppvth_lt=-0.063 mup_nb_ppvth_rt=-0.469 mup_nb_npvth_up=0.627 mup_nb_npvth_dn=0.181
+mup_no_ppvth_lt=-1.081 mup_no_ppvth_rt=-0.362 mup_no_npvth_up=0.053 mup_no_npvth_dn=0.852

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.241 mdn_inv_npvth=0.782
+mdn_na_ppvth_lt=-0.150 mdn_na_ppvth_rt=-0.143 mdn_na_npvth_up=0.227 mdn_na_npvth_dn=0.236
+mdn_nb_ppvth_lt=-0.341 mdn_nb_ppvth_rt=-0.427 mdn_nb_npvth_up=0.894 mdn_nb_npvth_dn=0.053
+mdn_no_ppvth_lt=-1.095 mdn_no_ppvth_rt=-0.078 mdn_no_npvth_up=0.707 mdn_no_npvth_dn=0.022
**

** 33 PUF stage
xi32 gnd net64 net65 ch_32 net66 net67 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.522 mup_inv_npvth=0.816
+mup_na_ppvth_lt=-0.260 mup_na_ppvth_rt=-0.588 mup_na_npvth_up=0.243 mup_na_npvth_dn=0.061
+mup_nb_ppvth_lt=-0.157 mup_nb_ppvth_rt=-0.401 mup_nb_npvth_up=0.138 mup_nb_npvth_dn=0.434
+mup_no_ppvth_lt=-0.487 mup_no_ppvth_rt=-0.273 mup_no_npvth_up=0.031 mup_no_npvth_dn=0.224

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.066 mdn_inv_npvth=0.115
+mdn_na_ppvth_lt=-0.053 mdn_na_ppvth_rt=-0.378 mdn_na_npvth_up=0.881 mdn_na_npvth_dn=0.213
+mdn_nb_ppvth_lt=-0.675 mdn_nb_ppvth_rt=-0.159 mdn_nb_npvth_up=0.327 mdn_nb_npvth_dn=0.147
+mdn_no_ppvth_lt=-0.652 mdn_no_ppvth_rt=-0.723 mdn_no_npvth_up=0.723 mdn_no_npvth_dn=0.157
**

** 34 PUF stage
xi33 gnd net66 net67 ch_33 net68 net69 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.314 mup_inv_npvth=0.298
+mup_na_ppvth_lt=-0.547 mup_na_ppvth_rt=-0.022 mup_na_npvth_up=0.222 mup_na_npvth_dn=0.056
+mup_nb_ppvth_lt=-0.244 mup_nb_ppvth_rt=-0.952 mup_nb_npvth_up=0.364 mup_nb_npvth_dn=0.226
+mup_no_ppvth_lt=-0.573 mup_no_ppvth_rt=-0.466 mup_no_npvth_up=0.290 mup_no_npvth_dn=0.727

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.046 mdn_inv_npvth=0.336
+mdn_na_ppvth_lt=-0.633 mdn_na_ppvth_rt=-0.404 mdn_na_npvth_up=0.581 mdn_na_npvth_dn=0.537
+mdn_nb_ppvth_lt=-0.444 mdn_nb_ppvth_rt=-0.280 mdn_nb_npvth_up=0.201 mdn_nb_npvth_dn=0.655
+mdn_no_ppvth_lt=-0.061 mdn_no_ppvth_rt=-0.038 mdn_no_npvth_up=0.017 mdn_no_npvth_dn=0.542
**

** 35 PUF stage
xi34 gnd net68 net69 ch_34 net70 net71 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.375 mup_inv_npvth=0.717
+mup_na_ppvth_lt=-0.764 mup_na_ppvth_rt=-0.106 mup_na_npvth_up=0.044 mup_na_npvth_dn=0.626
+mup_nb_ppvth_lt=-0.221 mup_nb_ppvth_rt=-0.490 mup_nb_npvth_up=0.874 mup_nb_npvth_dn=0.225
+mup_no_ppvth_lt=-0.542 mup_no_ppvth_rt=-0.821 mup_no_npvth_up=0.125 mup_no_npvth_dn=0.550

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.311 mdn_inv_npvth=0.845
+mdn_na_ppvth_lt=-0.701 mdn_na_ppvth_rt=-0.578 mdn_na_npvth_up=0.022 mdn_na_npvth_dn=0.932
+mdn_nb_ppvth_lt=-0.291 mdn_nb_ppvth_rt=-0.000 mdn_nb_npvth_up=0.393 mdn_nb_npvth_dn=0.100
+mdn_no_ppvth_lt=-0.215 mdn_no_ppvth_rt=-0.254 mdn_no_npvth_up=0.735 mdn_no_npvth_dn=0.204
**

** 36 PUF stage
xi35 gnd net70 net71 ch_35 net72 net73 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.321 mup_inv_npvth=0.764
+mup_na_ppvth_lt=-0.324 mup_na_ppvth_rt=-0.085 mup_na_npvth_up=0.293 mup_na_npvth_dn=0.443
+mup_nb_ppvth_lt=-0.042 mup_nb_ppvth_rt=-0.048 mup_nb_npvth_up=0.251 mup_nb_npvth_dn=0.021
+mup_no_ppvth_lt=-0.175 mup_no_ppvth_rt=-0.638 mup_no_npvth_up=0.465 mup_no_npvth_dn=0.159

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.945 mdn_inv_npvth=0.419
+mdn_na_ppvth_lt=-0.243 mdn_na_ppvth_rt=-1.034 mdn_na_npvth_up=0.188 mdn_na_npvth_dn=0.303
+mdn_nb_ppvth_lt=-0.047 mdn_nb_ppvth_rt=-0.439 mdn_nb_npvth_up=0.256 mdn_nb_npvth_dn=0.722
+mdn_no_ppvth_lt=-0.317 mdn_no_ppvth_rt=-0.090 mdn_no_npvth_up=0.127 mdn_no_npvth_dn=0.472
**

** 37 PUF stage
xi36 gnd net72 net73 ch_36 net74 net75 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.510 mup_inv_npvth=0.893
+mup_na_ppvth_lt=-0.000 mup_na_ppvth_rt=-0.511 mup_na_npvth_up=0.105 mup_na_npvth_dn=0.115
+mup_nb_ppvth_lt=-0.564 mup_nb_ppvth_rt=-0.216 mup_nb_npvth_up=0.231 mup_nb_npvth_dn=0.307
+mup_no_ppvth_lt=-0.037 mup_no_ppvth_rt=-0.243 mup_no_npvth_up=0.085 mup_no_npvth_dn=0.628

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.117 mdn_inv_npvth=0.247
+mdn_na_ppvth_lt=-0.752 mdn_na_ppvth_rt=-0.257 mdn_na_npvth_up=0.309 mdn_na_npvth_dn=0.322
+mdn_nb_ppvth_lt=-0.157 mdn_nb_ppvth_rt=-0.065 mdn_nb_npvth_up=0.538 mdn_nb_npvth_dn=0.141
+mdn_no_ppvth_lt=-0.988 mdn_no_ppvth_rt=-0.190 mdn_no_npvth_up=0.663 mdn_no_npvth_dn=0.432
**

** 38 PUF stage
xi37 gnd net74 net75 ch_37 net76 net77 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.149 mup_inv_npvth=0.718
+mup_na_ppvth_lt=-0.197 mup_na_ppvth_rt=-0.480 mup_na_npvth_up=0.563 mup_na_npvth_dn=0.161
+mup_nb_ppvth_lt=-0.328 mup_nb_ppvth_rt=-0.427 mup_nb_npvth_up=0.338 mup_nb_npvth_dn=0.331
+mup_no_ppvth_lt=-0.283 mup_no_ppvth_rt=-0.038 mup_no_npvth_up=0.313 mup_no_npvth_dn=0.383

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.285 mdn_inv_npvth=0.083
+mdn_na_ppvth_lt=-0.194 mdn_na_ppvth_rt=-0.232 mdn_na_npvth_up=0.395 mdn_na_npvth_dn=0.109
+mdn_nb_ppvth_lt=-0.837 mdn_nb_ppvth_rt=-0.558 mdn_nb_npvth_up=0.710 mdn_nb_npvth_dn=0.049
+mdn_no_ppvth_lt=-0.895 mdn_no_ppvth_rt=-0.100 mdn_no_npvth_up=0.788 mdn_no_npvth_dn=0.455
**

** 39 PUF stage
xi38 gnd net76 net77 ch_38 net78 net79 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.102 mup_inv_npvth=0.081
+mup_na_ppvth_lt=-0.019 mup_na_ppvth_rt=-0.484 mup_na_npvth_up=0.605 mup_na_npvth_dn=0.375
+mup_nb_ppvth_lt=-0.523 mup_nb_ppvth_rt=-0.467 mup_nb_npvth_up=0.586 mup_nb_npvth_dn=0.462
+mup_no_ppvth_lt=-0.248 mup_no_ppvth_rt=-0.232 mup_no_npvth_up=0.324 mup_no_npvth_dn=0.384

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.563 mdn_inv_npvth=0.046
+mdn_na_ppvth_lt=-0.751 mdn_na_ppvth_rt=-0.240 mdn_na_npvth_up=0.331 mdn_na_npvth_dn=0.049
+mdn_nb_ppvth_lt=-0.316 mdn_nb_ppvth_rt=-0.829 mdn_nb_npvth_up=0.078 mdn_nb_npvth_dn=0.255
+mdn_no_ppvth_lt=-0.316 mdn_no_ppvth_rt=-0.019 mdn_no_npvth_up=0.556 mdn_no_npvth_dn=0.693
**

** 40 PUF stage
xi39 gnd net78 net79 ch_39 net80 net81 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.568 mup_inv_npvth=0.766
+mup_na_ppvth_lt=-0.538 mup_na_ppvth_rt=-0.292 mup_na_npvth_up=0.117 mup_na_npvth_dn=0.474
+mup_nb_ppvth_lt=-0.253 mup_nb_ppvth_rt=-0.336 mup_nb_npvth_up=0.288 mup_nb_npvth_dn=0.072
+mup_no_ppvth_lt=-0.254 mup_no_ppvth_rt=-0.065 mup_no_npvth_up=0.070 mup_no_npvth_dn=0.246

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.600 mdn_inv_npvth=0.416
+mdn_na_ppvth_lt=-0.529 mdn_na_ppvth_rt=-0.361 mdn_na_npvth_up=0.185 mdn_na_npvth_dn=0.769
+mdn_nb_ppvth_lt=-0.210 mdn_nb_ppvth_rt=-0.137 mdn_nb_npvth_up=0.461 mdn_nb_npvth_dn=0.223
+mdn_no_ppvth_lt=-0.502 mdn_no_ppvth_rt=-0.479 mdn_no_npvth_up=0.162 mdn_no_npvth_dn=0.108
**

** 41 PUF stage
xi40 gnd net80 net81 ch_40 net82 net83 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.088 mup_inv_npvth=0.871
+mup_na_ppvth_lt=-0.384 mup_na_ppvth_rt=-0.309 mup_na_npvth_up=0.311 mup_na_npvth_dn=0.349
+mup_nb_ppvth_lt=-0.041 mup_nb_ppvth_rt=-0.144 mup_nb_npvth_up=0.018 mup_nb_npvth_dn=0.309
+mup_no_ppvth_lt=-0.119 mup_no_ppvth_rt=-0.301 mup_no_npvth_up=0.192 mup_no_npvth_dn=0.635

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.093 mdn_inv_npvth=0.232
+mdn_na_ppvth_lt=-0.044 mdn_na_ppvth_rt=-0.399 mdn_na_npvth_up=0.350 mdn_na_npvth_dn=0.395
+mdn_nb_ppvth_lt=-0.526 mdn_nb_ppvth_rt=-0.104 mdn_nb_npvth_up=0.095 mdn_nb_npvth_dn=0.220
+mdn_no_ppvth_lt=-1.184 mdn_no_ppvth_rt=-0.359 mdn_no_npvth_up=0.562 mdn_no_npvth_dn=0.520
**

** 42 PUF stage
xi41 gnd net82 net83 ch_41 net84 net85 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.331 mup_inv_npvth=0.265
+mup_na_ppvth_lt=-0.259 mup_na_ppvth_rt=-0.125 mup_na_npvth_up=0.010 mup_na_npvth_dn=0.593
+mup_nb_ppvth_lt=-0.870 mup_nb_ppvth_rt=-0.020 mup_nb_npvth_up=0.474 mup_nb_npvth_dn=0.077
+mup_no_ppvth_lt=-0.490 mup_no_ppvth_rt=-0.201 mup_no_npvth_up=0.033 mup_no_npvth_dn=0.519

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.295 mdn_inv_npvth=1.092
+mdn_na_ppvth_lt=-0.178 mdn_na_ppvth_rt=-0.186 mdn_na_npvth_up=0.854 mdn_na_npvth_dn=0.472
+mdn_nb_ppvth_lt=-0.177 mdn_nb_ppvth_rt=-0.062 mdn_nb_npvth_up=0.597 mdn_nb_npvth_dn=0.509
+mdn_no_ppvth_lt=-0.173 mdn_no_ppvth_rt=-0.202 mdn_no_npvth_up=0.318 mdn_no_npvth_dn=0.108
**

** 43 PUF stage
xi42 gnd net84 net85 ch_42 net86 net87 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.556 mup_inv_npvth=0.200
+mup_na_ppvth_lt=-1.020 mup_na_ppvth_rt=-0.562 mup_na_npvth_up=0.754 mup_na_npvth_dn=0.150
+mup_nb_ppvth_lt=-0.792 mup_nb_ppvth_rt=-0.360 mup_nb_npvth_up=0.718 mup_nb_npvth_dn=0.383
+mup_no_ppvth_lt=-0.617 mup_no_ppvth_rt=-0.411 mup_no_npvth_up=0.372 mup_no_npvth_dn=0.000

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.062 mdn_inv_npvth=0.269
+mdn_na_ppvth_lt=-0.075 mdn_na_ppvth_rt=-0.449 mdn_na_npvth_up=0.191 mdn_na_npvth_dn=0.528
+mdn_nb_ppvth_lt=-0.005 mdn_nb_ppvth_rt=-0.467 mdn_nb_npvth_up=0.142 mdn_nb_npvth_dn=0.025
+mdn_no_ppvth_lt=-0.397 mdn_no_ppvth_rt=-0.728 mdn_no_npvth_up=0.506 mdn_no_npvth_dn=0.795
**

** 44 PUF stage
xi43 gnd net86 net87 ch_43 net88 net89 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.484 mup_inv_npvth=0.088
+mup_na_ppvth_lt=-0.882 mup_na_ppvth_rt=-0.234 mup_na_npvth_up=0.683 mup_na_npvth_dn=0.004
+mup_nb_ppvth_lt=-0.462 mup_nb_ppvth_rt=-0.385 mup_nb_npvth_up=0.255 mup_nb_npvth_dn=0.419
+mup_no_ppvth_lt=-0.085 mup_no_ppvth_rt=-0.519 mup_no_npvth_up=0.828 mup_no_npvth_dn=0.073

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.672 mdn_inv_npvth=0.392
+mdn_na_ppvth_lt=-0.451 mdn_na_ppvth_rt=-0.602 mdn_na_npvth_up=0.340 mdn_na_npvth_dn=0.623
+mdn_nb_ppvth_lt=-0.005 mdn_nb_ppvth_rt=-0.069 mdn_nb_npvth_up=0.356 mdn_nb_npvth_dn=0.478
+mdn_no_ppvth_lt=-0.303 mdn_no_ppvth_rt=-0.447 mdn_no_npvth_up=0.203 mdn_no_npvth_dn=0.163
**

** 45 PUF stage
xi44 gnd net88 net89 ch_44 net90 net91 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.344 mup_inv_npvth=0.190
+mup_na_ppvth_lt=-0.313 mup_na_ppvth_rt=-0.070 mup_na_npvth_up=0.076 mup_na_npvth_dn=0.451
+mup_nb_ppvth_lt=-0.562 mup_nb_ppvth_rt=-0.506 mup_nb_npvth_up=0.144 mup_nb_npvth_dn=0.383
+mup_no_ppvth_lt=-0.392 mup_no_ppvth_rt=-0.340 mup_no_npvth_up=0.126 mup_no_npvth_dn=0.328

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.032 mdn_inv_npvth=0.479
+mdn_na_ppvth_lt=-1.164 mdn_na_ppvth_rt=-0.118 mdn_na_npvth_up=0.090 mdn_na_npvth_dn=0.054
+mdn_nb_ppvth_lt=-0.000 mdn_nb_ppvth_rt=-0.142 mdn_nb_npvth_up=0.211 mdn_nb_npvth_dn=0.317
+mdn_no_ppvth_lt=-0.524 mdn_no_ppvth_rt=-1.191 mdn_no_npvth_up=0.352 mdn_no_npvth_dn=0.220
**

** 46 PUF stage
xi45 gnd net90 net91 ch_45 net92 net93 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.093 mup_inv_npvth=0.328
+mup_na_ppvth_lt=-0.405 mup_na_ppvth_rt=-0.617 mup_na_npvth_up=0.015 mup_na_npvth_dn=0.380
+mup_nb_ppvth_lt=-0.257 mup_nb_ppvth_rt=-0.220 mup_nb_npvth_up=0.036 mup_nb_npvth_dn=0.020
+mup_no_ppvth_lt=-0.675 mup_no_ppvth_rt=-0.031 mup_no_npvth_up=0.434 mup_no_npvth_dn=1.163

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.759 mdn_inv_npvth=0.030
+mdn_na_ppvth_lt=-0.371 mdn_na_ppvth_rt=-0.454 mdn_na_npvth_up=0.440 mdn_na_npvth_dn=0.204
+mdn_nb_ppvth_lt=-0.197 mdn_nb_ppvth_rt=-0.552 mdn_nb_npvth_up=0.488 mdn_nb_npvth_dn=0.162
+mdn_no_ppvth_lt=-0.560 mdn_no_ppvth_rt=-0.288 mdn_no_npvth_up=0.035 mdn_no_npvth_dn=0.374
**

** 47 PUF stage
xi46 gnd net92 net93 ch_46 net94 net95 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.457 mup_inv_npvth=0.868
+mup_na_ppvth_lt=-0.662 mup_na_ppvth_rt=-0.546 mup_na_npvth_up=0.425 mup_na_npvth_dn=0.547
+mup_nb_ppvth_lt=-0.204 mup_nb_ppvth_rt=-0.251 mup_nb_npvth_up=0.061 mup_nb_npvth_dn=0.849
+mup_no_ppvth_lt=-0.256 mup_no_ppvth_rt=-1.042 mup_no_npvth_up=0.342 mup_no_npvth_dn=0.307

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.315 mdn_inv_npvth=0.481
+mdn_na_ppvth_lt=-0.545 mdn_na_ppvth_rt=-0.213 mdn_na_npvth_up=0.402 mdn_na_npvth_dn=0.193
+mdn_nb_ppvth_lt=-0.004 mdn_nb_ppvth_rt=-0.087 mdn_nb_npvth_up=0.232 mdn_nb_npvth_dn=0.471
+mdn_no_ppvth_lt=-0.206 mdn_no_ppvth_rt=-0.543 mdn_no_npvth_up=0.209 mdn_no_npvth_dn=0.035
**

** 48 PUF stage
xi47 gnd net94 net95 ch_47 net96 net97 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.434 mup_inv_npvth=0.199
+mup_na_ppvth_lt=-0.084 mup_na_ppvth_rt=-0.349 mup_na_npvth_up=0.596 mup_na_npvth_dn=0.028
+mup_nb_ppvth_lt=-0.154 mup_nb_ppvth_rt=-0.572 mup_nb_npvth_up=0.056 mup_nb_npvth_dn=0.327
+mup_no_ppvth_lt=-0.029 mup_no_ppvth_rt=-0.319 mup_no_npvth_up=0.247 mup_no_npvth_dn=0.378

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.991 mdn_inv_npvth=0.242
+mdn_na_ppvth_lt=-0.589 mdn_na_ppvth_rt=-0.466 mdn_na_npvth_up=0.456 mdn_na_npvth_dn=1.012
+mdn_nb_ppvth_lt=-0.269 mdn_nb_ppvth_rt=-0.066 mdn_nb_npvth_up=0.226 mdn_nb_npvth_dn=0.247
+mdn_no_ppvth_lt=-0.112 mdn_no_ppvth_rt=-0.478 mdn_no_npvth_up=0.502 mdn_no_npvth_dn=0.110
**

** 49 PUF stage
xi48 gnd net96 net97 ch_48 net98 net99 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.222 mup_inv_npvth=0.748
+mup_na_ppvth_lt=-0.353 mup_na_ppvth_rt=-0.241 mup_na_npvth_up=0.499 mup_na_npvth_dn=0.451
+mup_nb_ppvth_lt=-0.106 mup_nb_ppvth_rt=-0.184 mup_nb_npvth_up=0.019 mup_nb_npvth_dn=0.101
+mup_no_ppvth_lt=-0.356 mup_no_ppvth_rt=-0.006 mup_no_npvth_up=1.075 mup_no_npvth_dn=0.342

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.035 mdn_inv_npvth=0.511
+mdn_na_ppvth_lt=-0.285 mdn_na_ppvth_rt=-0.079 mdn_na_npvth_up=0.333 mdn_na_npvth_dn=0.262
+mdn_nb_ppvth_lt=-0.313 mdn_nb_ppvth_rt=-0.355 mdn_nb_npvth_up=0.230 mdn_nb_npvth_dn=0.139
+mdn_no_ppvth_lt=-0.809 mdn_no_ppvth_rt=-0.032 mdn_no_npvth_up=0.618 mdn_no_npvth_dn=0.682
**

** 50 PUF stage
xi49 gnd net98 net99 ch_49 net100 net101 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.656 mup_inv_npvth=0.591
+mup_na_ppvth_lt=-0.078 mup_na_ppvth_rt=-0.603 mup_na_npvth_up=0.459 mup_na_npvth_dn=0.262
+mup_nb_ppvth_lt=-0.147 mup_nb_ppvth_rt=-0.388 mup_nb_npvth_up=0.059 mup_nb_npvth_dn=0.236
+mup_no_ppvth_lt=-1.052 mup_no_ppvth_rt=-0.174 mup_no_npvth_up=0.121 mup_no_npvth_dn=0.118

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.156 mdn_inv_npvth=0.537
+mdn_na_ppvth_lt=-0.390 mdn_na_ppvth_rt=-0.159 mdn_na_npvth_up=0.188 mdn_na_npvth_dn=0.225
+mdn_nb_ppvth_lt=-0.190 mdn_nb_ppvth_rt=-0.363 mdn_nb_npvth_up=0.711 mdn_nb_npvth_dn=0.157
+mdn_no_ppvth_lt=-0.237 mdn_no_ppvth_rt=-0.701 mdn_no_npvth_up=0.149 mdn_no_npvth_dn=0.094
**

** 51 PUF stage
xi50 gnd net100 net101 ch_50 net102 net103 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.140 mup_inv_npvth=0.257
+mup_na_ppvth_lt=-0.707 mup_na_ppvth_rt=-0.389 mup_na_npvth_up=0.069 mup_na_npvth_dn=0.603
+mup_nb_ppvth_lt=-0.237 mup_nb_ppvth_rt=-0.487 mup_nb_npvth_up=1.040 mup_nb_npvth_dn=0.365
+mup_no_ppvth_lt=-0.109 mup_no_ppvth_rt=-0.178 mup_no_npvth_up=0.488 mup_no_npvth_dn=0.166

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.212 mdn_inv_npvth=0.399
+mdn_na_ppvth_lt=-0.000 mdn_na_ppvth_rt=-0.139 mdn_na_npvth_up=0.305 mdn_na_npvth_dn=0.288
+mdn_nb_ppvth_lt=-0.363 mdn_nb_ppvth_rt=-0.422 mdn_nb_npvth_up=0.361 mdn_nb_npvth_dn=0.738
+mdn_no_ppvth_lt=-0.743 mdn_no_ppvth_rt=-0.272 mdn_no_npvth_up=0.330 mdn_no_npvth_dn=0.316
**

** 52 PUF stage
xi51 gnd net102 net103 ch_51 net104 net105 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.316 mup_inv_npvth=0.232
+mup_na_ppvth_lt=-0.091 mup_na_ppvth_rt=-0.924 mup_na_npvth_up=0.130 mup_na_npvth_dn=0.848
+mup_nb_ppvth_lt=-0.219 mup_nb_ppvth_rt=-0.192 mup_nb_npvth_up=0.556 mup_nb_npvth_dn=0.506
+mup_no_ppvth_lt=-0.063 mup_no_ppvth_rt=-0.090 mup_no_npvth_up=0.754 mup_no_npvth_dn=0.263

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.379 mdn_inv_npvth=0.143
+mdn_na_ppvth_lt=-0.916 mdn_na_ppvth_rt=-0.119 mdn_na_npvth_up=0.155 mdn_na_npvth_dn=0.502
+mdn_nb_ppvth_lt=-0.360 mdn_nb_ppvth_rt=-0.395 mdn_nb_npvth_up=0.180 mdn_nb_npvth_dn=0.396
+mdn_no_ppvth_lt=-0.089 mdn_no_ppvth_rt=-0.078 mdn_no_npvth_up=0.714 mdn_no_npvth_dn=0.636
**

** 53 PUF stage
xi52 gnd net104 net105 ch_52 net106 net107 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.325 mup_inv_npvth=0.619
+mup_na_ppvth_lt=-0.266 mup_na_ppvth_rt=-0.023 mup_na_npvth_up=0.056 mup_na_npvth_dn=0.345
+mup_nb_ppvth_lt=-0.235 mup_nb_ppvth_rt=-0.594 mup_nb_npvth_up=0.807 mup_nb_npvth_dn=0.112
+mup_no_ppvth_lt=-0.001 mup_no_ppvth_rt=-0.151 mup_no_npvth_up=0.093 mup_no_npvth_dn=0.089

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.050 mdn_inv_npvth=0.514
+mdn_na_ppvth_lt=-0.418 mdn_na_ppvth_rt=-0.425 mdn_na_npvth_up=0.174 mdn_na_npvth_dn=0.183
+mdn_nb_ppvth_lt=-0.390 mdn_nb_ppvth_rt=-0.127 mdn_nb_npvth_up=0.415 mdn_nb_npvth_dn=0.498
+mdn_no_ppvth_lt=-0.127 mdn_no_ppvth_rt=-0.141 mdn_no_npvth_up=0.348 mdn_no_npvth_dn=0.109
**

** 54 PUF stage
xi53 gnd net106 net107 ch_53 net108 net109 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.151 mup_inv_npvth=0.329
+mup_na_ppvth_lt=-0.240 mup_na_ppvth_rt=-0.365 mup_na_npvth_up=0.064 mup_na_npvth_dn=0.942
+mup_nb_ppvth_lt=-0.032 mup_nb_ppvth_rt=-0.642 mup_nb_npvth_up=0.148 mup_nb_npvth_dn=0.735
+mup_no_ppvth_lt=-0.340 mup_no_ppvth_rt=-0.114 mup_no_npvth_up=0.077 mup_no_npvth_dn=0.221

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.251 mdn_inv_npvth=0.241
+mdn_na_ppvth_lt=-0.371 mdn_na_ppvth_rt=-0.337 mdn_na_npvth_up=0.090 mdn_na_npvth_dn=0.205
+mdn_nb_ppvth_lt=-0.348 mdn_nb_ppvth_rt=-0.237 mdn_nb_npvth_up=0.164 mdn_nb_npvth_dn=0.141
+mdn_no_ppvth_lt=-0.068 mdn_no_ppvth_rt=-0.392 mdn_no_npvth_up=0.542 mdn_no_npvth_dn=0.595
**

** 55 PUF stage
xi54 gnd net108 net109 ch_54 net110 net111 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.104 mup_inv_npvth=0.033
+mup_na_ppvth_lt=-0.107 mup_na_ppvth_rt=-0.316 mup_na_npvth_up=0.077 mup_na_npvth_dn=0.039
+mup_nb_ppvth_lt=-0.538 mup_nb_ppvth_rt=-0.140 mup_nb_npvth_up=0.334 mup_nb_npvth_dn=0.130
+mup_no_ppvth_lt=-0.489 mup_no_ppvth_rt=-0.095 mup_no_npvth_up=0.108 mup_no_npvth_dn=0.493

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.467 mdn_inv_npvth=0.188
+mdn_na_ppvth_lt=-0.341 mdn_na_ppvth_rt=-0.036 mdn_na_npvth_up=0.612 mdn_na_npvth_dn=0.677
+mdn_nb_ppvth_lt=-0.402 mdn_nb_ppvth_rt=-0.096 mdn_nb_npvth_up=0.619 mdn_nb_npvth_dn=0.020
+mdn_no_ppvth_lt=-0.259 mdn_no_ppvth_rt=-0.513 mdn_no_npvth_up=0.013 mdn_no_npvth_dn=0.334
**

** 56 PUF stage
xi55 gnd net110 net111 ch_55 net112 net113 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.695 mup_inv_npvth=0.560
+mup_na_ppvth_lt=-0.747 mup_na_ppvth_rt=-0.805 mup_na_npvth_up=0.554 mup_na_npvth_dn=0.067
+mup_nb_ppvth_lt=-0.555 mup_nb_ppvth_rt=-0.038 mup_nb_npvth_up=0.208 mup_nb_npvth_dn=0.250
+mup_no_ppvth_lt=-0.413 mup_no_ppvth_rt=-0.552 mup_no_npvth_up=0.774 mup_no_npvth_dn=0.154

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.222 mdn_inv_npvth=0.250
+mdn_na_ppvth_lt=-0.430 mdn_na_ppvth_rt=-1.320 mdn_na_npvth_up=0.093 mdn_na_npvth_dn=0.054
+mdn_nb_ppvth_lt=-0.102 mdn_nb_ppvth_rt=-0.346 mdn_nb_npvth_up=0.051 mdn_nb_npvth_dn=0.212
+mdn_no_ppvth_lt=-0.193 mdn_no_ppvth_rt=-0.314 mdn_no_npvth_up=0.112 mdn_no_npvth_dn=0.229
**

** 57 PUF stage
xi56 gnd net112 net113 ch_56 net114 net115 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.152 mup_inv_npvth=0.103
+mup_na_ppvth_lt=-0.188 mup_na_ppvth_rt=-0.879 mup_na_npvth_up=0.711 mup_na_npvth_dn=0.332
+mup_nb_ppvth_lt=-0.243 mup_nb_ppvth_rt=-0.059 mup_nb_npvth_up=0.529 mup_nb_npvth_dn=0.920
+mup_no_ppvth_lt=-0.344 mup_no_ppvth_rt=-0.237 mup_no_npvth_up=0.654 mup_no_npvth_dn=0.083

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.010 mdn_inv_npvth=0.401
+mdn_na_ppvth_lt=-0.566 mdn_na_ppvth_rt=-0.328 mdn_na_npvth_up=0.363 mdn_na_npvth_dn=0.413
+mdn_nb_ppvth_lt=-0.101 mdn_nb_ppvth_rt=-0.140 mdn_nb_npvth_up=0.259 mdn_nb_npvth_dn=0.072
+mdn_no_ppvth_lt=-0.546 mdn_no_ppvth_rt=-0.021 mdn_no_npvth_up=0.697 mdn_no_npvth_dn=0.217
**

** 58 PUF stage
xi57 gnd net114 net115 ch_57 net116 net117 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.170 mup_inv_npvth=0.296
+mup_na_ppvth_lt=-0.052 mup_na_ppvth_rt=-0.331 mup_na_npvth_up=0.585 mup_na_npvth_dn=0.451
+mup_nb_ppvth_lt=-0.058 mup_nb_ppvth_rt=-0.127 mup_nb_npvth_up=0.181 mup_nb_npvth_dn=0.371
+mup_no_ppvth_lt=-0.611 mup_no_ppvth_rt=-0.307 mup_no_npvth_up=0.518 mup_no_npvth_dn=0.105

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.583 mdn_inv_npvth=0.407
+mdn_na_ppvth_lt=-0.190 mdn_na_ppvth_rt=-0.056 mdn_na_npvth_up=0.326 mdn_na_npvth_dn=0.363
+mdn_nb_ppvth_lt=-0.159 mdn_nb_ppvth_rt=-0.535 mdn_nb_npvth_up=0.422 mdn_nb_npvth_dn=0.373
+mdn_no_ppvth_lt=-0.059 mdn_no_ppvth_rt=-0.262 mdn_no_npvth_up=0.088 mdn_no_npvth_dn=0.011
**

** 59 PUF stage
xi58 gnd net116 net117 ch_58 net118 net119 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.531 mup_inv_npvth=0.343
+mup_na_ppvth_lt=-0.799 mup_na_ppvth_rt=-0.617 mup_na_npvth_up=0.398 mup_na_npvth_dn=0.300
+mup_nb_ppvth_lt=-0.122 mup_nb_ppvth_rt=-0.401 mup_nb_npvth_up=0.966 mup_nb_npvth_dn=0.486
+mup_no_ppvth_lt=-0.240 mup_no_ppvth_rt=-1.125 mup_no_npvth_up=0.070 mup_no_npvth_dn=0.289

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.366 mdn_inv_npvth=0.805
+mdn_na_ppvth_lt=-0.373 mdn_na_ppvth_rt=-0.101 mdn_na_npvth_up=0.193 mdn_na_npvth_dn=0.376
+mdn_nb_ppvth_lt=-1.224 mdn_nb_ppvth_rt=-0.499 mdn_nb_npvth_up=0.021 mdn_nb_npvth_dn=0.072
+mdn_no_ppvth_lt=-0.577 mdn_no_ppvth_rt=-0.198 mdn_no_npvth_up=0.389 mdn_no_npvth_dn=0.538
**

** 60 PUF stage
xi59 gnd net118 net119 ch_59 net120 net121 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.552 mup_inv_npvth=0.359
+mup_na_ppvth_lt=-0.142 mup_na_ppvth_rt=-0.218 mup_na_npvth_up=0.302 mup_na_npvth_dn=0.252
+mup_nb_ppvth_lt=-0.079 mup_nb_ppvth_rt=-0.101 mup_nb_npvth_up=0.473 mup_nb_npvth_dn=0.626
+mup_no_ppvth_lt=-0.073 mup_no_ppvth_rt=-0.308 mup_no_npvth_up=0.334 mup_no_npvth_dn=0.028

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.395 mdn_inv_npvth=0.344
+mdn_na_ppvth_lt=-0.007 mdn_na_ppvth_rt=-0.361 mdn_na_npvth_up=0.059 mdn_na_npvth_dn=0.258
+mdn_nb_ppvth_lt=-0.529 mdn_nb_ppvth_rt=-0.250 mdn_nb_npvth_up=0.308 mdn_nb_npvth_dn=0.512
+mdn_no_ppvth_lt=-0.144 mdn_no_ppvth_rt=-0.551 mdn_no_npvth_up=0.144 mdn_no_npvth_dn=0.304
**

** 61 PUF stage
xi60 gnd net120 net121 ch_60 net122 net123 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.393 mup_inv_npvth=0.091
+mup_na_ppvth_lt=-0.224 mup_na_ppvth_rt=-0.144 mup_na_npvth_up=0.479 mup_na_npvth_dn=0.119
+mup_nb_ppvth_lt=-0.086 mup_nb_ppvth_rt=-0.309 mup_nb_npvth_up=1.283 mup_nb_npvth_dn=1.106
+mup_no_ppvth_lt=-0.236 mup_no_ppvth_rt=-0.366 mup_no_npvth_up=0.337 mup_no_npvth_dn=1.035

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.053 mdn_inv_npvth=0.450
+mdn_na_ppvth_lt=-0.656 mdn_na_ppvth_rt=-0.073 mdn_na_npvth_up=0.862 mdn_na_npvth_dn=0.164
+mdn_nb_ppvth_lt=-0.335 mdn_nb_ppvth_rt=-0.473 mdn_nb_npvth_up=0.176 mdn_nb_npvth_dn=0.666
+mdn_no_ppvth_lt=-0.253 mdn_no_ppvth_rt=-0.551 mdn_no_npvth_up=0.326 mdn_no_npvth_dn=0.131
**

** 62 PUF stage
xi61 gnd net122 net123 ch_61 net124 net125 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.069 mup_inv_npvth=0.362
+mup_na_ppvth_lt=-0.370 mup_na_ppvth_rt=-0.138 mup_na_npvth_up=0.398 mup_na_npvth_dn=0.027
+mup_nb_ppvth_lt=-0.014 mup_nb_ppvth_rt=-0.507 mup_nb_npvth_up=0.913 mup_nb_npvth_dn=0.041
+mup_no_ppvth_lt=-0.338 mup_no_ppvth_rt=-0.694 mup_no_npvth_up=0.632 mup_no_npvth_dn=0.908

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.515 mdn_inv_npvth=0.352
+mdn_na_ppvth_lt=-0.231 mdn_na_ppvth_rt=-0.035 mdn_na_npvth_up=0.156 mdn_na_npvth_dn=0.593
+mdn_nb_ppvth_lt=-0.080 mdn_nb_ppvth_rt=-0.024 mdn_nb_npvth_up=0.578 mdn_nb_npvth_dn=0.274
+mdn_no_ppvth_lt=-0.184 mdn_no_ppvth_rt=-0.223 mdn_no_npvth_up=0.262 mdn_no_npvth_dn=0.211
**

** 63 PUF stage
xi62 gnd net124 net125 ch_62 net126 net127 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.180 mup_inv_npvth=0.236
+mup_na_ppvth_lt=-0.820 mup_na_ppvth_rt=-0.812 mup_na_npvth_up=0.297 mup_na_npvth_dn=0.490
+mup_nb_ppvth_lt=-1.053 mup_nb_ppvth_rt=-0.245 mup_nb_npvth_up=0.949 mup_nb_npvth_dn=0.073
+mup_no_ppvth_lt=-0.949 mup_no_ppvth_rt=-0.862 mup_no_npvth_up=0.286 mup_no_npvth_dn=0.242

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.086 mdn_inv_npvth=0.198
+mdn_na_ppvth_lt=-0.864 mdn_na_ppvth_rt=-0.664 mdn_na_npvth_up=0.278 mdn_na_npvth_dn=0.051
+mdn_nb_ppvth_lt=-0.216 mdn_nb_ppvth_rt=-0.648 mdn_nb_npvth_up=0.010 mdn_nb_npvth_dn=0.383
+mdn_no_ppvth_lt=-0.469 mdn_no_ppvth_rt=-0.604 mdn_no_npvth_up=0.043 mdn_no_npvth_dn=0.545
**

** 64 PUF stage
xi63 gnd net126 net127 ch_63 net128 net129 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.603 mup_inv_npvth=0.126
+mup_na_ppvth_lt=-0.082 mup_na_ppvth_rt=-0.305 mup_na_npvth_up=0.152 mup_na_npvth_dn=0.685
+mup_nb_ppvth_lt=-0.809 mup_nb_ppvth_rt=-0.346 mup_nb_npvth_up=0.614 mup_nb_npvth_dn=0.336
+mup_no_ppvth_lt=-0.296 mup_no_ppvth_rt=-0.094 mup_no_npvth_up=0.061 mup_no_npvth_dn=0.299

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.475 mdn_inv_npvth=0.837
+mdn_na_ppvth_lt=-0.179 mdn_na_ppvth_rt=-0.068 mdn_na_npvth_up=0.346 mdn_na_npvth_dn=0.356
+mdn_nb_ppvth_lt=-0.550 mdn_nb_ppvth_rt=-0.107 mdn_nb_npvth_up=0.074 mdn_nb_npvth_dn=0.395
+mdn_no_ppvth_lt=-0.080 mdn_no_ppvth_rt=-0.133 mdn_no_npvth_up=0.478 mdn_no_npvth_dn=0.489
**

** 65 PUF stage
xi64 gnd net128 net129 ch_64 net130 net131 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.702 mup_inv_npvth=0.053
+mup_na_ppvth_lt=-0.062 mup_na_ppvth_rt=-0.967 mup_na_npvth_up=0.089 mup_na_npvth_dn=0.505
+mup_nb_ppvth_lt=-0.403 mup_nb_ppvth_rt=-0.220 mup_nb_npvth_up=0.364 mup_nb_npvth_dn=0.492
+mup_no_ppvth_lt=-0.324 mup_no_ppvth_rt=-0.403 mup_no_npvth_up=0.719 mup_no_npvth_dn=0.134

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.232 mdn_inv_npvth=0.490
+mdn_na_ppvth_lt=-0.214 mdn_na_ppvth_rt=-0.013 mdn_na_npvth_up=0.039 mdn_na_npvth_dn=0.241
+mdn_nb_ppvth_lt=-0.436 mdn_nb_ppvth_rt=-0.008 mdn_nb_npvth_up=0.339 mdn_nb_npvth_dn=0.179
+mdn_no_ppvth_lt=-0.049 mdn_no_ppvth_rt=-0.264 mdn_no_npvth_up=0.361 mdn_no_npvth_dn=0.056
**

** 66 PUF stage
xi65 gnd net130 net131 ch_65 net132 net133 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.543 mup_inv_npvth=0.828
+mup_na_ppvth_lt=-0.098 mup_na_ppvth_rt=-0.627 mup_na_npvth_up=0.369 mup_na_npvth_dn=0.230
+mup_nb_ppvth_lt=-0.005 mup_nb_ppvth_rt=-0.230 mup_nb_npvth_up=0.069 mup_nb_npvth_dn=0.037
+mup_no_ppvth_lt=-0.523 mup_no_ppvth_rt=-0.002 mup_no_npvth_up=0.123 mup_no_npvth_dn=0.695

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.158 mdn_inv_npvth=0.669
+mdn_na_ppvth_lt=-0.208 mdn_na_ppvth_rt=-0.433 mdn_na_npvth_up=0.108 mdn_na_npvth_dn=0.394
+mdn_nb_ppvth_lt=-0.272 mdn_nb_ppvth_rt=-0.389 mdn_nb_npvth_up=0.392 mdn_nb_npvth_dn=0.392
+mdn_no_ppvth_lt=-0.366 mdn_no_ppvth_rt=-0.081 mdn_no_npvth_up=0.141 mdn_no_npvth_dn=0.854
**

** 67 PUF stage
xi66 gnd net132 net133 ch_66 net134 net135 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.094 mup_inv_npvth=0.465
+mup_na_ppvth_lt=-0.074 mup_na_ppvth_rt=-0.174 mup_na_npvth_up=0.507 mup_na_npvth_dn=0.457
+mup_nb_ppvth_lt=-0.292 mup_nb_ppvth_rt=-0.097 mup_nb_npvth_up=0.049 mup_nb_npvth_dn=0.755
+mup_no_ppvth_lt=-0.007 mup_no_ppvth_rt=-0.415 mup_no_npvth_up=0.414 mup_no_npvth_dn=0.933

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.385 mdn_inv_npvth=0.435
+mdn_na_ppvth_lt=-0.043 mdn_na_ppvth_rt=-0.431 mdn_na_npvth_up=0.757 mdn_na_npvth_dn=0.127
+mdn_nb_ppvth_lt=-0.073 mdn_nb_ppvth_rt=-0.252 mdn_nb_npvth_up=0.247 mdn_nb_npvth_dn=0.085
+mdn_no_ppvth_lt=-0.157 mdn_no_ppvth_rt=-0.094 mdn_no_npvth_up=0.732 mdn_no_npvth_dn=0.383
**

** 68 PUF stage
xi67 gnd net134 net135 ch_67 net136 net137 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.721 mup_inv_npvth=0.213
+mup_na_ppvth_lt=-0.139 mup_na_ppvth_rt=-0.733 mup_na_npvth_up=0.407 mup_na_npvth_dn=0.118
+mup_nb_ppvth_lt=-0.186 mup_nb_ppvth_rt=-0.324 mup_nb_npvth_up=0.643 mup_nb_npvth_dn=0.724
+mup_no_ppvth_lt=-0.354 mup_no_ppvth_rt=-0.839 mup_no_npvth_up=0.006 mup_no_npvth_dn=0.562

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.222 mdn_inv_npvth=0.091
+mdn_na_ppvth_lt=-0.318 mdn_na_ppvth_rt=-0.404 mdn_na_npvth_up=0.008 mdn_na_npvth_dn=0.476
+mdn_nb_ppvth_lt=-0.853 mdn_nb_ppvth_rt=-0.194 mdn_nb_npvth_up=0.125 mdn_nb_npvth_dn=0.305
+mdn_no_ppvth_lt=-0.515 mdn_no_ppvth_rt=-0.362 mdn_no_npvth_up=0.974 mdn_no_npvth_dn=0.286
**

** 69 PUF stage
xi68 gnd net136 net137 ch_68 net138 net139 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.568 mup_inv_npvth=0.313
+mup_na_ppvth_lt=-0.098 mup_na_ppvth_rt=-0.009 mup_na_npvth_up=0.169 mup_na_npvth_dn=0.523
+mup_nb_ppvth_lt=-0.014 mup_nb_ppvth_rt=-0.072 mup_nb_npvth_up=0.008 mup_nb_npvth_dn=0.748
+mup_no_ppvth_lt=-0.113 mup_no_ppvth_rt=-0.179 mup_no_npvth_up=0.140 mup_no_npvth_dn=0.444

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.021 mdn_inv_npvth=0.561
+mdn_na_ppvth_lt=-0.062 mdn_na_ppvth_rt=-0.472 mdn_na_npvth_up=0.697 mdn_na_npvth_dn=0.185
+mdn_nb_ppvth_lt=-0.292 mdn_nb_ppvth_rt=-0.112 mdn_nb_npvth_up=0.364 mdn_nb_npvth_dn=0.045
+mdn_no_ppvth_lt=-0.098 mdn_no_ppvth_rt=-0.547 mdn_no_npvth_up=0.490 mdn_no_npvth_dn=0.845
**

** 70 PUF stage
xi69 gnd net138 net139 ch_69 net140 net141 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.251 mup_inv_npvth=0.335
+mup_na_ppvth_lt=-0.193 mup_na_ppvth_rt=-0.348 mup_na_npvth_up=0.209 mup_na_npvth_dn=0.320
+mup_nb_ppvth_lt=-0.220 mup_nb_ppvth_rt=-0.213 mup_nb_npvth_up=0.120 mup_nb_npvth_dn=0.091
+mup_no_ppvth_lt=-0.279 mup_no_ppvth_rt=-0.609 mup_no_npvth_up=0.434 mup_no_npvth_dn=0.071

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.562 mdn_inv_npvth=0.095
+mdn_na_ppvth_lt=-0.197 mdn_na_ppvth_rt=-0.130 mdn_na_npvth_up=0.155 mdn_na_npvth_dn=0.465
+mdn_nb_ppvth_lt=-0.090 mdn_nb_ppvth_rt=-0.181 mdn_nb_npvth_up=0.077 mdn_nb_npvth_dn=0.028
+mdn_no_ppvth_lt=-0.373 mdn_no_ppvth_rt=-0.416 mdn_no_npvth_up=0.872 mdn_no_npvth_dn=0.229
**

** 71 PUF stage
xi70 gnd net140 net141 ch_70 net142 net143 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.285 mup_inv_npvth=0.849
+mup_na_ppvth_lt=-0.030 mup_na_ppvth_rt=-0.383 mup_na_npvth_up=0.526 mup_na_npvth_dn=0.184
+mup_nb_ppvth_lt=-0.352 mup_nb_ppvth_rt=-0.816 mup_nb_npvth_up=0.881 mup_nb_npvth_dn=0.537
+mup_no_ppvth_lt=-0.302 mup_no_ppvth_rt=-0.265 mup_no_npvth_up=0.011 mup_no_npvth_dn=0.492

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.395 mdn_inv_npvth=0.449
+mdn_na_ppvth_lt=-0.105 mdn_na_ppvth_rt=-0.069 mdn_na_npvth_up=0.247 mdn_na_npvth_dn=0.510
+mdn_nb_ppvth_lt=-0.260 mdn_nb_ppvth_rt=-0.616 mdn_nb_npvth_up=0.288 mdn_nb_npvth_dn=0.737
+mdn_no_ppvth_lt=-0.375 mdn_no_ppvth_rt=-0.563 mdn_no_npvth_up=0.219 mdn_no_npvth_dn=0.663
**

** 72 PUF stage
xi71 gnd net142 net143 ch_71 net144 net145 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.036 mup_inv_npvth=0.754
+mup_na_ppvth_lt=-0.356 mup_na_ppvth_rt=-0.024 mup_na_npvth_up=0.043 mup_na_npvth_dn=0.287
+mup_nb_ppvth_lt=-0.583 mup_nb_ppvth_rt=-0.374 mup_nb_npvth_up=0.760 mup_nb_npvth_dn=0.132
+mup_no_ppvth_lt=-0.080 mup_no_ppvth_rt=-0.750 mup_no_npvth_up=0.377 mup_no_npvth_dn=0.163

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.354 mdn_inv_npvth=0.012
+mdn_na_ppvth_lt=-0.256 mdn_na_ppvth_rt=-0.868 mdn_na_npvth_up=0.593 mdn_na_npvth_dn=0.286
+mdn_nb_ppvth_lt=-0.019 mdn_nb_ppvth_rt=-0.281 mdn_nb_npvth_up=0.559 mdn_nb_npvth_dn=0.504
+mdn_no_ppvth_lt=-0.474 mdn_no_ppvth_rt=-0.009 mdn_no_npvth_up=0.905 mdn_no_npvth_dn=0.012
**

** 73 PUF stage
xi72 gnd net144 net145 ch_72 net146 net147 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.675 mup_inv_npvth=0.331
+mup_na_ppvth_lt=-0.398 mup_na_ppvth_rt=-0.312 mup_na_npvth_up=0.754 mup_na_npvth_dn=0.291
+mup_nb_ppvth_lt=-0.128 mup_nb_ppvth_rt=-0.422 mup_nb_npvth_up=0.320 mup_nb_npvth_dn=0.545
+mup_no_ppvth_lt=-0.351 mup_no_ppvth_rt=-0.058 mup_no_npvth_up=0.238 mup_no_npvth_dn=0.420

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.384 mdn_inv_npvth=0.348
+mdn_na_ppvth_lt=-0.027 mdn_na_ppvth_rt=-0.122 mdn_na_npvth_up=0.717 mdn_na_npvth_dn=0.449
+mdn_nb_ppvth_lt=-0.429 mdn_nb_ppvth_rt=-0.020 mdn_nb_npvth_up=0.971 mdn_nb_npvth_dn=0.594
+mdn_no_ppvth_lt=-0.042 mdn_no_ppvth_rt=-0.322 mdn_no_npvth_up=0.037 mdn_no_npvth_dn=0.378
**

** 74 PUF stage
xi73 gnd net146 net147 ch_73 net148 net149 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.614 mup_inv_npvth=0.403
+mup_na_ppvth_lt=-0.427 mup_na_ppvth_rt=-0.162 mup_na_npvth_up=0.118 mup_na_npvth_dn=0.886
+mup_nb_ppvth_lt=-0.306 mup_nb_ppvth_rt=-0.248 mup_nb_npvth_up=0.677 mup_nb_npvth_dn=0.243
+mup_no_ppvth_lt=-0.000 mup_no_ppvth_rt=-0.227 mup_no_npvth_up=0.124 mup_no_npvth_dn=0.328

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.208 mdn_inv_npvth=0.278
+mdn_na_ppvth_lt=-1.043 mdn_na_ppvth_rt=-0.007 mdn_na_npvth_up=0.807 mdn_na_npvth_dn=0.443
+mdn_nb_ppvth_lt=-0.258 mdn_nb_ppvth_rt=-0.068 mdn_nb_npvth_up=0.250 mdn_nb_npvth_dn=0.336
+mdn_no_ppvth_lt=-0.293 mdn_no_ppvth_rt=-0.418 mdn_no_npvth_up=0.693 mdn_no_npvth_dn=0.008
**

** 75 PUF stage
xi74 gnd net148 net149 ch_74 net150 net151 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.711 mup_inv_npvth=0.295
+mup_na_ppvth_lt=-0.013 mup_na_ppvth_rt=-0.486 mup_na_npvth_up=0.246 mup_na_npvth_dn=0.440
+mup_nb_ppvth_lt=-0.324 mup_nb_ppvth_rt=-0.522 mup_nb_npvth_up=0.643 mup_nb_npvth_dn=0.374
+mup_no_ppvth_lt=-0.290 mup_no_ppvth_rt=-0.651 mup_no_npvth_up=0.266 mup_no_npvth_dn=0.542

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.071 mdn_inv_npvth=0.695
+mdn_na_ppvth_lt=-0.569 mdn_na_ppvth_rt=-0.179 mdn_na_npvth_up=0.059 mdn_na_npvth_dn=0.037
+mdn_nb_ppvth_lt=-0.266 mdn_nb_ppvth_rt=-0.231 mdn_nb_npvth_up=0.438 mdn_nb_npvth_dn=0.175
+mdn_no_ppvth_lt=-0.666 mdn_no_ppvth_rt=-0.598 mdn_no_npvth_up=0.520 mdn_no_npvth_dn=0.319
**

** 76 PUF stage
xi75 gnd net150 net151 ch_75 net152 net153 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.289 mup_inv_npvth=0.454
+mup_na_ppvth_lt=-0.695 mup_na_ppvth_rt=-0.021 mup_na_npvth_up=0.019 mup_na_npvth_dn=0.282
+mup_nb_ppvth_lt=-0.336 mup_nb_ppvth_rt=-0.301 mup_nb_npvth_up=0.403 mup_nb_npvth_dn=0.801
+mup_no_ppvth_lt=-0.552 mup_no_ppvth_rt=-0.104 mup_no_npvth_up=0.275 mup_no_npvth_dn=0.188

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.426 mdn_inv_npvth=0.661
+mdn_na_ppvth_lt=-0.311 mdn_na_ppvth_rt=-0.542 mdn_na_npvth_up=0.002 mdn_na_npvth_dn=0.409
+mdn_nb_ppvth_lt=-0.278 mdn_nb_ppvth_rt=-0.045 mdn_nb_npvth_up=0.404 mdn_nb_npvth_dn=0.845
+mdn_no_ppvth_lt=-0.226 mdn_no_ppvth_rt=-0.238 mdn_no_npvth_up=0.423 mdn_no_npvth_dn=0.671
**

** 77 PUF stage
xi76 gnd net152 net153 ch_76 net154 net155 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.361 mup_inv_npvth=0.319
+mup_na_ppvth_lt=-0.291 mup_na_ppvth_rt=-0.795 mup_na_npvth_up=0.821 mup_na_npvth_dn=0.384
+mup_nb_ppvth_lt=-0.645 mup_nb_ppvth_rt=-0.519 mup_nb_npvth_up=0.287 mup_nb_npvth_dn=0.011
+mup_no_ppvth_lt=-0.592 mup_no_ppvth_rt=-0.807 mup_no_npvth_up=1.049 mup_no_npvth_dn=0.534

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.146 mdn_inv_npvth=0.086
+mdn_na_ppvth_lt=-0.825 mdn_na_ppvth_rt=-1.106 mdn_na_npvth_up=0.183 mdn_na_npvth_dn=0.077
+mdn_nb_ppvth_lt=-0.172 mdn_nb_ppvth_rt=-0.125 mdn_nb_npvth_up=0.512 mdn_nb_npvth_dn=0.656
+mdn_no_ppvth_lt=-0.040 mdn_no_ppvth_rt=-1.153 mdn_no_npvth_up=0.376 mdn_no_npvth_dn=0.311
**

** 78 PUF stage
xi77 gnd net154 net155 ch_77 net156 net157 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.628 mup_inv_npvth=0.431
+mup_na_ppvth_lt=-0.080 mup_na_ppvth_rt=-0.398 mup_na_npvth_up=0.320 mup_na_npvth_dn=0.504
+mup_nb_ppvth_lt=-0.535 mup_nb_ppvth_rt=-0.781 mup_nb_npvth_up=0.857 mup_nb_npvth_dn=0.223
+mup_no_ppvth_lt=-0.051 mup_no_ppvth_rt=-0.185 mup_no_npvth_up=0.426 mup_no_npvth_dn=0.834

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.189 mdn_inv_npvth=0.391
+mdn_na_ppvth_lt=-0.281 mdn_na_ppvth_rt=-0.256 mdn_na_npvth_up=0.174 mdn_na_npvth_dn=0.223
+mdn_nb_ppvth_lt=-0.303 mdn_nb_ppvth_rt=-0.720 mdn_nb_npvth_up=0.038 mdn_nb_npvth_dn=0.619
+mdn_no_ppvth_lt=-0.202 mdn_no_ppvth_rt=-0.276 mdn_no_npvth_up=0.293 mdn_no_npvth_dn=0.021
**

** 79 PUF stage
xi78 gnd net156 net157 ch_78 net158 net159 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.098 mup_inv_npvth=0.253
+mup_na_ppvth_lt=-0.083 mup_na_ppvth_rt=-0.356 mup_na_npvth_up=0.333 mup_na_npvth_dn=0.100
+mup_nb_ppvth_lt=-0.329 mup_nb_ppvth_rt=-0.264 mup_nb_npvth_up=0.193 mup_nb_npvth_dn=0.915
+mup_no_ppvth_lt=-0.009 mup_no_ppvth_rt=-0.043 mup_no_npvth_up=0.474 mup_no_npvth_dn=0.186

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.931 mdn_inv_npvth=0.145
+mdn_na_ppvth_lt=-0.874 mdn_na_ppvth_rt=-0.564 mdn_na_npvth_up=0.615 mdn_na_npvth_dn=0.483
+mdn_nb_ppvth_lt=-0.406 mdn_nb_ppvth_rt=-0.845 mdn_nb_npvth_up=0.295 mdn_nb_npvth_dn=0.351
+mdn_no_ppvth_lt=-0.634 mdn_no_ppvth_rt=-0.309 mdn_no_npvth_up=0.856 mdn_no_npvth_dn=0.709
**

** 80 PUF stage
xi79 gnd net158 net159 ch_79 net160 net161 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.204 mup_inv_npvth=0.113
+mup_na_ppvth_lt=-0.099 mup_na_ppvth_rt=-0.357 mup_na_npvth_up=0.165 mup_na_npvth_dn=0.023
+mup_nb_ppvth_lt=-0.380 mup_nb_ppvth_rt=-0.604 mup_nb_npvth_up=0.029 mup_nb_npvth_dn=0.659
+mup_no_ppvth_lt=-0.038 mup_no_ppvth_rt=-0.327 mup_no_npvth_up=0.101 mup_no_npvth_dn=0.084

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.998 mdn_inv_npvth=0.827
+mdn_na_ppvth_lt=-0.765 mdn_na_ppvth_rt=-0.277 mdn_na_npvth_up=0.101 mdn_na_npvth_dn=0.101
+mdn_nb_ppvth_lt=-0.117 mdn_nb_ppvth_rt=-0.006 mdn_nb_npvth_up=0.649 mdn_nb_npvth_dn=0.272
+mdn_no_ppvth_lt=-0.867 mdn_no_ppvth_rt=-0.539 mdn_no_npvth_up=0.310 mdn_no_npvth_dn=0.535
**

** 81 PUF stage
xi80 gnd net160 net161 ch_80 net162 net163 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.386 mup_inv_npvth=0.146
+mup_na_ppvth_lt=-0.327 mup_na_ppvth_rt=-0.565 mup_na_npvth_up=0.445 mup_na_npvth_dn=0.120
+mup_nb_ppvth_lt=-0.380 mup_nb_ppvth_rt=-0.794 mup_nb_npvth_up=0.820 mup_nb_npvth_dn=0.290
+mup_no_ppvth_lt=-0.196 mup_no_ppvth_rt=-0.294 mup_no_npvth_up=0.720 mup_no_npvth_dn=0.613

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.139 mdn_inv_npvth=0.998
+mdn_na_ppvth_lt=-0.361 mdn_na_ppvth_rt=-0.307 mdn_na_npvth_up=0.154 mdn_na_npvth_dn=0.101
+mdn_nb_ppvth_lt=-0.105 mdn_nb_ppvth_rt=-0.525 mdn_nb_npvth_up=0.272 mdn_nb_npvth_dn=0.210
+mdn_no_ppvth_lt=-0.139 mdn_no_ppvth_rt=-0.531 mdn_no_npvth_up=0.672 mdn_no_npvth_dn=0.418
**

** 82 PUF stage
xi81 gnd net162 net163 ch_81 net164 net165 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.038 mup_inv_npvth=0.199
+mup_na_ppvth_lt=-0.851 mup_na_ppvth_rt=-0.424 mup_na_npvth_up=0.238 mup_na_npvth_dn=0.377
+mup_nb_ppvth_lt=-0.138 mup_nb_ppvth_rt=-0.593 mup_nb_npvth_up=0.513 mup_nb_npvth_dn=0.502
+mup_no_ppvth_lt=-0.228 mup_no_ppvth_rt=-0.056 mup_no_npvth_up=1.044 mup_no_npvth_dn=0.336

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.887 mdn_inv_npvth=0.118
+mdn_na_ppvth_lt=-0.347 mdn_na_ppvth_rt=-0.047 mdn_na_npvth_up=0.294 mdn_na_npvth_dn=0.542
+mdn_nb_ppvth_lt=-0.053 mdn_nb_ppvth_rt=-0.441 mdn_nb_npvth_up=0.058 mdn_nb_npvth_dn=0.393
+mdn_no_ppvth_lt=-0.330 mdn_no_ppvth_rt=-0.243 mdn_no_npvth_up=0.264 mdn_no_npvth_dn=1.160
**

** 83 PUF stage
xi82 gnd net164 net165 ch_82 net166 net167 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.072 mup_inv_npvth=0.067
+mup_na_ppvth_lt=-0.014 mup_na_ppvth_rt=-0.588 mup_na_npvth_up=1.219 mup_na_npvth_dn=0.432
+mup_nb_ppvth_lt=-0.319 mup_nb_ppvth_rt=-0.700 mup_nb_npvth_up=0.246 mup_nb_npvth_dn=0.157
+mup_no_ppvth_lt=-0.901 mup_no_ppvth_rt=-0.232 mup_no_npvth_up=0.899 mup_no_npvth_dn=0.227

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.563 mdn_inv_npvth=0.207
+mdn_na_ppvth_lt=-0.534 mdn_na_ppvth_rt=-0.181 mdn_na_npvth_up=0.654 mdn_na_npvth_dn=0.108
+mdn_nb_ppvth_lt=-0.004 mdn_nb_ppvth_rt=-0.788 mdn_nb_npvth_up=0.561 mdn_nb_npvth_dn=0.078
+mdn_no_ppvth_lt=-0.105 mdn_no_ppvth_rt=-0.590 mdn_no_npvth_up=0.003 mdn_no_npvth_dn=0.142
**

** 84 PUF stage
xi83 gnd net166 net167 ch_83 net168 net169 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.285 mup_inv_npvth=0.016
+mup_na_ppvth_lt=-0.290 mup_na_ppvth_rt=-0.027 mup_na_npvth_up=0.508 mup_na_npvth_dn=0.151
+mup_nb_ppvth_lt=-0.493 mup_nb_ppvth_rt=-0.191 mup_nb_npvth_up=0.185 mup_nb_npvth_dn=0.329
+mup_no_ppvth_lt=-0.797 mup_no_ppvth_rt=-0.273 mup_no_npvth_up=0.527 mup_no_npvth_dn=0.235

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.771 mdn_inv_npvth=0.422
+mdn_na_ppvth_lt=-0.406 mdn_na_ppvth_rt=-0.635 mdn_na_npvth_up=0.550 mdn_na_npvth_dn=0.274
+mdn_nb_ppvth_lt=-0.133 mdn_nb_ppvth_rt=-1.004 mdn_nb_npvth_up=0.622 mdn_nb_npvth_dn=0.123
+mdn_no_ppvth_lt=-0.494 mdn_no_ppvth_rt=-0.514 mdn_no_npvth_up=0.360 mdn_no_npvth_dn=0.420
**

** 85 PUF stage
xi84 gnd net168 net169 ch_84 net170 net171 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.477 mup_inv_npvth=0.485
+mup_na_ppvth_lt=-0.351 mup_na_ppvth_rt=-0.096 mup_na_npvth_up=0.292 mup_na_npvth_dn=0.246
+mup_nb_ppvth_lt=-0.001 mup_nb_ppvth_rt=-0.079 mup_nb_npvth_up=0.050 mup_nb_npvth_dn=0.927
+mup_no_ppvth_lt=-0.645 mup_no_ppvth_rt=-0.530 mup_no_npvth_up=0.122 mup_no_npvth_dn=0.113

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.058 mdn_inv_npvth=0.620
+mdn_na_ppvth_lt=-0.114 mdn_na_ppvth_rt=-0.603 mdn_na_npvth_up=0.054 mdn_na_npvth_dn=0.646
+mdn_nb_ppvth_lt=-0.339 mdn_nb_ppvth_rt=-0.121 mdn_nb_npvth_up=0.739 mdn_nb_npvth_dn=0.183
+mdn_no_ppvth_lt=-0.024 mdn_no_ppvth_rt=-0.711 mdn_no_npvth_up=0.004 mdn_no_npvth_dn=0.014
**

** 86 PUF stage
xi85 gnd net170 net171 ch_85 net172 net173 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.050 mup_inv_npvth=0.341
+mup_na_ppvth_lt=-0.526 mup_na_ppvth_rt=-0.253 mup_na_npvth_up=0.276 mup_na_npvth_dn=0.133
+mup_nb_ppvth_lt=-0.553 mup_nb_ppvth_rt=-0.110 mup_nb_npvth_up=0.244 mup_nb_npvth_dn=0.283
+mup_no_ppvth_lt=-0.810 mup_no_ppvth_rt=-0.542 mup_no_npvth_up=0.675 mup_no_npvth_dn=0.913

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.338 mdn_inv_npvth=0.524
+mdn_na_ppvth_lt=-0.235 mdn_na_ppvth_rt=-0.187 mdn_na_npvth_up=0.268 mdn_na_npvth_dn=0.447
+mdn_nb_ppvth_lt=-0.690 mdn_nb_ppvth_rt=-0.639 mdn_nb_npvth_up=0.102 mdn_nb_npvth_dn=0.232
+mdn_no_ppvth_lt=-0.191 mdn_no_ppvth_rt=-0.088 mdn_no_npvth_up=0.535 mdn_no_npvth_dn=0.981
**

** 87 PUF stage
xi86 gnd net172 net173 ch_86 net174 net175 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.296 mup_inv_npvth=1.100
+mup_na_ppvth_lt=-0.579 mup_na_ppvth_rt=-0.448 mup_na_npvth_up=0.903 mup_na_npvth_dn=0.479
+mup_nb_ppvth_lt=-0.584 mup_nb_ppvth_rt=-0.339 mup_nb_npvth_up=0.080 mup_nb_npvth_dn=0.070
+mup_no_ppvth_lt=-0.035 mup_no_ppvth_rt=-0.459 mup_no_npvth_up=0.220 mup_no_npvth_dn=0.278

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.093 mdn_inv_npvth=0.158
+mdn_na_ppvth_lt=-0.806 mdn_na_ppvth_rt=-0.784 mdn_na_npvth_up=0.427 mdn_na_npvth_dn=0.461
+mdn_nb_ppvth_lt=-1.008 mdn_nb_ppvth_rt=-0.471 mdn_nb_npvth_up=0.890 mdn_nb_npvth_dn=0.515
+mdn_no_ppvth_lt=-0.252 mdn_no_ppvth_rt=-0.183 mdn_no_npvth_up=0.362 mdn_no_npvth_dn=0.062
**

** 88 PUF stage
xi87 gnd net174 net175 ch_87 net176 net177 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.115 mup_inv_npvth=0.340
+mup_na_ppvth_lt=-0.078 mup_na_ppvth_rt=-0.480 mup_na_npvth_up=0.211 mup_na_npvth_dn=0.355
+mup_nb_ppvth_lt=-0.756 mup_nb_ppvth_rt=-0.242 mup_nb_npvth_up=0.540 mup_nb_npvth_dn=0.540
+mup_no_ppvth_lt=-0.073 mup_no_ppvth_rt=-0.345 mup_no_npvth_up=0.087 mup_no_npvth_dn=0.001

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.407 mdn_inv_npvth=0.409
+mdn_na_ppvth_lt=-0.065 mdn_na_ppvth_rt=-0.156 mdn_na_npvth_up=0.139 mdn_na_npvth_dn=0.286
+mdn_nb_ppvth_lt=-0.398 mdn_nb_ppvth_rt=-0.151 mdn_nb_npvth_up=0.043 mdn_nb_npvth_dn=0.079
+mdn_no_ppvth_lt=-0.140 mdn_no_ppvth_rt=-0.425 mdn_no_npvth_up=0.310 mdn_no_npvth_dn=0.368
**

** 89 PUF stage
xi88 gnd net176 net177 ch_88 net178 net179 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.225 mup_inv_npvth=0.657
+mup_na_ppvth_lt=-0.821 mup_na_ppvth_rt=-0.009 mup_na_npvth_up=0.299 mup_na_npvth_dn=0.062
+mup_nb_ppvth_lt=-0.374 mup_nb_ppvth_rt=-0.097 mup_nb_npvth_up=0.007 mup_nb_npvth_dn=0.022
+mup_no_ppvth_lt=-0.507 mup_no_ppvth_rt=-0.384 mup_no_npvth_up=0.730 mup_no_npvth_dn=0.178

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.584 mdn_inv_npvth=0.084
+mdn_na_ppvth_lt=-0.202 mdn_na_ppvth_rt=-0.248 mdn_na_npvth_up=0.769 mdn_na_npvth_dn=0.602
+mdn_nb_ppvth_lt=-0.149 mdn_nb_ppvth_rt=-0.105 mdn_nb_npvth_up=0.068 mdn_nb_npvth_dn=0.422
+mdn_no_ppvth_lt=-0.168 mdn_no_ppvth_rt=-0.099 mdn_no_npvth_up=0.289 mdn_no_npvth_dn=0.071
**

** 90 PUF stage
xi89 gnd net178 net179 ch_89 net180 net181 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.818 mup_inv_npvth=0.504
+mup_na_ppvth_lt=-0.051 mup_na_ppvth_rt=-0.380 mup_na_npvth_up=0.157 mup_na_npvth_dn=0.418
+mup_nb_ppvth_lt=-0.642 mup_nb_ppvth_rt=-0.235 mup_nb_npvth_up=0.140 mup_nb_npvth_dn=0.063
+mup_no_ppvth_lt=-0.633 mup_no_ppvth_rt=-0.181 mup_no_npvth_up=0.489 mup_no_npvth_dn=1.048

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.178 mdn_inv_npvth=0.267
+mdn_na_ppvth_lt=-0.068 mdn_na_ppvth_rt=-0.476 mdn_na_npvth_up=0.579 mdn_na_npvth_dn=0.520
+mdn_nb_ppvth_lt=-0.357 mdn_nb_ppvth_rt=-0.243 mdn_nb_npvth_up=0.887 mdn_nb_npvth_dn=0.000
+mdn_no_ppvth_lt=-0.310 mdn_no_ppvth_rt=-0.148 mdn_no_npvth_up=0.070 mdn_no_npvth_dn=0.074
**

** 91 PUF stage
xi90 gnd net180 net181 ch_90 net182 net183 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.155 mup_inv_npvth=0.046
+mup_na_ppvth_lt=-0.226 mup_na_ppvth_rt=-0.210 mup_na_npvth_up=0.395 mup_na_npvth_dn=0.240
+mup_nb_ppvth_lt=-0.108 mup_nb_ppvth_rt=-0.115 mup_nb_npvth_up=0.126 mup_nb_npvth_dn=0.118
+mup_no_ppvth_lt=-0.165 mup_no_ppvth_rt=-0.367 mup_no_npvth_up=0.154 mup_no_npvth_dn=0.232

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.060 mdn_inv_npvth=0.974
+mdn_na_ppvth_lt=-0.610 mdn_na_ppvth_rt=-0.063 mdn_na_npvth_up=0.466 mdn_na_npvth_dn=0.343
+mdn_nb_ppvth_lt=-0.933 mdn_nb_ppvth_rt=-0.353 mdn_nb_npvth_up=0.369 mdn_nb_npvth_dn=0.488
+mdn_no_ppvth_lt=-0.142 mdn_no_ppvth_rt=-0.109 mdn_no_npvth_up=0.240 mdn_no_npvth_dn=0.234
**

** 92 PUF stage
xi91 gnd net182 net183 ch_91 net184 net185 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.241 mup_inv_npvth=0.680
+mup_na_ppvth_lt=-0.461 mup_na_ppvth_rt=-0.442 mup_na_npvth_up=0.755 mup_na_npvth_dn=0.523
+mup_nb_ppvth_lt=-0.333 mup_nb_ppvth_rt=-0.272 mup_nb_npvth_up=0.203 mup_nb_npvth_dn=0.042
+mup_no_ppvth_lt=-0.655 mup_no_ppvth_rt=-0.009 mup_no_npvth_up=0.263 mup_no_npvth_dn=0.017

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.318 mdn_inv_npvth=0.403
+mdn_na_ppvth_lt=-0.156 mdn_na_ppvth_rt=-0.317 mdn_na_npvth_up=0.636 mdn_na_npvth_dn=0.377
+mdn_nb_ppvth_lt=-0.149 mdn_nb_ppvth_rt=-0.170 mdn_nb_npvth_up=0.501 mdn_nb_npvth_dn=0.316
+mdn_no_ppvth_lt=-0.268 mdn_no_ppvth_rt=-0.201 mdn_no_npvth_up=0.004 mdn_no_npvth_dn=0.085
**

** 93 PUF stage
xi92 gnd net184 net185 ch_92 net186 net187 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.149 mup_inv_npvth=0.116
+mup_na_ppvth_lt=-0.134 mup_na_ppvth_rt=-0.193 mup_na_npvth_up=0.168 mup_na_npvth_dn=0.080
+mup_nb_ppvth_lt=-0.116 mup_nb_ppvth_rt=-0.457 mup_nb_npvth_up=0.411 mup_nb_npvth_dn=0.038
+mup_no_ppvth_lt=-0.056 mup_no_ppvth_rt=-0.953 mup_no_npvth_up=0.713 mup_no_npvth_dn=0.664

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.217 mdn_inv_npvth=0.177
+mdn_na_ppvth_lt=-0.021 mdn_na_ppvth_rt=-0.809 mdn_na_npvth_up=0.033 mdn_na_npvth_dn=0.522
+mdn_nb_ppvth_lt=-0.425 mdn_nb_ppvth_rt=-0.336 mdn_nb_npvth_up=1.026 mdn_nb_npvth_dn=0.023
+mdn_no_ppvth_lt=-0.467 mdn_no_ppvth_rt=-0.208 mdn_no_npvth_up=0.357 mdn_no_npvth_dn=0.460
**

** 94 PUF stage
xi93 gnd net186 net187 ch_93 net188 net189 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.074 mup_inv_npvth=0.337
+mup_na_ppvth_lt=-0.217 mup_na_ppvth_rt=-0.530 mup_na_npvth_up=0.418 mup_na_npvth_dn=0.510
+mup_nb_ppvth_lt=-0.131 mup_nb_ppvth_rt=-0.586 mup_nb_npvth_up=0.090 mup_nb_npvth_dn=0.214
+mup_no_ppvth_lt=-0.525 mup_no_ppvth_rt=-0.083 mup_no_npvth_up=0.267 mup_no_npvth_dn=0.517

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.240 mdn_inv_npvth=0.346
+mdn_na_ppvth_lt=-0.084 mdn_na_ppvth_rt=-0.476 mdn_na_npvth_up=0.692 mdn_na_npvth_dn=0.281
+mdn_nb_ppvth_lt=-0.022 mdn_nb_ppvth_rt=-0.141 mdn_nb_npvth_up=0.412 mdn_nb_npvth_dn=0.409
+mdn_no_ppvth_lt=-0.697 mdn_no_ppvth_rt=-0.902 mdn_no_npvth_up=0.371 mdn_no_npvth_dn=0.023
**

** 95 PUF stage
xi94 gnd net188 net189 ch_94 net190 net191 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.049 mup_inv_npvth=0.068
+mup_na_ppvth_lt=-0.184 mup_na_ppvth_rt=-0.935 mup_na_npvth_up=0.412 mup_na_npvth_dn=0.669
+mup_nb_ppvth_lt=-0.366 mup_nb_ppvth_rt=-0.340 mup_nb_npvth_up=0.258 mup_nb_npvth_dn=0.120
+mup_no_ppvth_lt=-0.016 mup_no_ppvth_rt=-0.823 mup_no_npvth_up=0.126 mup_no_npvth_dn=0.310

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.342 mdn_inv_npvth=0.297
+mdn_na_ppvth_lt=-0.566 mdn_na_ppvth_rt=-0.101 mdn_na_npvth_up=0.697 mdn_na_npvth_dn=0.021
+mdn_nb_ppvth_lt=-0.610 mdn_nb_ppvth_rt=-0.207 mdn_nb_npvth_up=0.117 mdn_nb_npvth_dn=0.734
+mdn_no_ppvth_lt=-0.526 mdn_no_ppvth_rt=-0.509 mdn_no_npvth_up=0.962 mdn_no_npvth_dn=0.259
**

** 96 PUF stage
xi95 gnd net190 net191 ch_95 net192 net193 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.769 mup_inv_npvth=0.015
+mup_na_ppvth_lt=-0.712 mup_na_ppvth_rt=-0.039 mup_na_npvth_up=0.488 mup_na_npvth_dn=0.526
+mup_nb_ppvth_lt=-0.201 mup_nb_ppvth_rt=-0.538 mup_nb_npvth_up=0.293 mup_nb_npvth_dn=0.129
+mup_no_ppvth_lt=-0.036 mup_no_ppvth_rt=-0.288 mup_no_npvth_up=0.444 mup_no_npvth_dn=0.918

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.192 mdn_inv_npvth=1.149
+mdn_na_ppvth_lt=-0.629 mdn_na_ppvth_rt=-0.296 mdn_na_npvth_up=0.243 mdn_na_npvth_dn=0.682
+mdn_nb_ppvth_lt=-0.077 mdn_nb_ppvth_rt=-0.439 mdn_nb_npvth_up=0.079 mdn_nb_npvth_dn=0.392
+mdn_no_ppvth_lt=-0.238 mdn_no_ppvth_rt=-0.404 mdn_no_npvth_up=0.898 mdn_no_npvth_dn=0.570
**

** 97 PUF stage
xi96 gnd net192 net193 ch_96 net194 net195 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.069 mup_inv_npvth=0.203
+mup_na_ppvth_lt=-0.456 mup_na_ppvth_rt=-0.497 mup_na_npvth_up=0.088 mup_na_npvth_dn=0.418
+mup_nb_ppvth_lt=-0.546 mup_nb_ppvth_rt=-0.245 mup_nb_npvth_up=0.120 mup_nb_npvth_dn=0.093
+mup_no_ppvth_lt=-0.135 mup_no_ppvth_rt=-0.069 mup_no_npvth_up=0.295 mup_no_npvth_dn=0.122

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.018 mdn_inv_npvth=0.845
+mdn_na_ppvth_lt=-0.330 mdn_na_ppvth_rt=-0.553 mdn_na_npvth_up=0.665 mdn_na_npvth_dn=0.078
+mdn_nb_ppvth_lt=-0.333 mdn_nb_ppvth_rt=-0.371 mdn_nb_npvth_up=0.104 mdn_nb_npvth_dn=0.115
+mdn_no_ppvth_lt=-0.352 mdn_no_ppvth_rt=-0.286 mdn_no_npvth_up=0.671 mdn_no_npvth_dn=0.385
**

** 98 PUF stage
xi97 gnd net194 net195 ch_97 net196 net197 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.435 mup_inv_npvth=0.539
+mup_na_ppvth_lt=-0.014 mup_na_ppvth_rt=-0.027 mup_na_npvth_up=0.006 mup_na_npvth_dn=1.057
+mup_nb_ppvth_lt=-0.483 mup_nb_ppvth_rt=-0.427 mup_nb_npvth_up=0.396 mup_nb_npvth_dn=0.010
+mup_no_ppvth_lt=-0.316 mup_no_ppvth_rt=-0.154 mup_no_npvth_up=0.344 mup_no_npvth_dn=0.490

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.467 mdn_inv_npvth=0.170
+mdn_na_ppvth_lt=-0.165 mdn_na_ppvth_rt=-0.815 mdn_na_npvth_up=0.277 mdn_na_npvth_dn=0.078
+mdn_nb_ppvth_lt=-0.192 mdn_nb_ppvth_rt=-0.096 mdn_nb_npvth_up=0.331 mdn_nb_npvth_dn=0.004
+mdn_no_ppvth_lt=-0.858 mdn_no_ppvth_rt=-0.493 mdn_no_npvth_up=0.949 mdn_no_npvth_dn=0.519
**

** 99 PUF stage
xi98 gnd net196 net197 ch_98 net198 net199 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.782 mup_inv_npvth=0.702
+mup_na_ppvth_lt=-0.729 mup_na_ppvth_rt=-0.245 mup_na_npvth_up=0.455 mup_na_npvth_dn=0.132
+mup_nb_ppvth_lt=-0.301 mup_nb_ppvth_rt=-0.469 mup_nb_npvth_up=0.412 mup_nb_npvth_dn=0.313
+mup_no_ppvth_lt=-0.406 mup_no_ppvth_rt=-0.139 mup_no_npvth_up=0.222 mup_no_npvth_dn=0.868

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.303 mdn_inv_npvth=0.521
+mdn_na_ppvth_lt=-0.301 mdn_na_ppvth_rt=-0.181 mdn_na_npvth_up=0.157 mdn_na_npvth_dn=0.115
+mdn_nb_ppvth_lt=-0.107 mdn_nb_ppvth_rt=-0.223 mdn_nb_npvth_up=0.018 mdn_nb_npvth_dn=0.484
+mdn_no_ppvth_lt=-0.467 mdn_no_ppvth_rt=-0.075 mdn_no_npvth_up=0.266 mdn_no_npvth_dn=0.105
**

** 100 PUF stage
xi99 gnd net198 net199 ch_99 net200 net201 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.642 mup_inv_npvth=0.074
+mup_na_ppvth_lt=-0.311 mup_na_ppvth_rt=-0.567 mup_na_npvth_up=0.720 mup_na_npvth_dn=0.033
+mup_nb_ppvth_lt=-0.602 mup_nb_ppvth_rt=-0.117 mup_nb_npvth_up=0.085 mup_nb_npvth_dn=0.570
+mup_no_ppvth_lt=-0.279 mup_no_ppvth_rt=-0.569 mup_no_npvth_up=0.006 mup_no_npvth_dn=0.208

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.057 mdn_inv_npvth=0.511
+mdn_na_ppvth_lt=-0.477 mdn_na_ppvth_rt=-0.598 mdn_na_npvth_up=0.820 mdn_na_npvth_dn=0.191
+mdn_nb_ppvth_lt=-0.215 mdn_nb_ppvth_rt=-0.056 mdn_nb_npvth_up=0.489 mdn_nb_npvth_dn=0.142
+mdn_no_ppvth_lt=-0.166 mdn_no_ppvth_rt=-0.159 mdn_no_npvth_up=0.350 mdn_no_npvth_dn=0.144
**

** 101 PUF stage
xi100 gnd net200 net201 ch_100 net202 net203 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.399 mup_inv_npvth=0.004
+mup_na_ppvth_lt=-0.300 mup_na_ppvth_rt=-0.521 mup_na_npvth_up=0.694 mup_na_npvth_dn=0.055
+mup_nb_ppvth_lt=-0.885 mup_nb_ppvth_rt=-0.109 mup_nb_npvth_up=0.722 mup_nb_npvth_dn=0.684
+mup_no_ppvth_lt=-0.275 mup_no_ppvth_rt=-0.547 mup_no_npvth_up=0.275 mup_no_npvth_dn=0.757

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.013 mdn_inv_npvth=0.127
+mdn_na_ppvth_lt=-0.273 mdn_na_ppvth_rt=-0.078 mdn_na_npvth_up=0.404 mdn_na_npvth_dn=0.653
+mdn_nb_ppvth_lt=-0.203 mdn_nb_ppvth_rt=-1.181 mdn_nb_npvth_up=0.204 mdn_nb_npvth_dn=0.388
+mdn_no_ppvth_lt=-0.560 mdn_no_ppvth_rt=-0.115 mdn_no_npvth_up=0.353 mdn_no_npvth_dn=0.298
**

** 102 PUF stage
xi101 gnd net202 net203 ch_101 net204 net205 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.579 mup_inv_npvth=0.191
+mup_na_ppvth_lt=-0.814 mup_na_ppvth_rt=-0.264 mup_na_npvth_up=0.454 mup_na_npvth_dn=0.657
+mup_nb_ppvth_lt=-0.060 mup_nb_ppvth_rt=-0.686 mup_nb_npvth_up=0.019 mup_nb_npvth_dn=1.074
+mup_no_ppvth_lt=-0.094 mup_no_ppvth_rt=-0.733 mup_no_npvth_up=0.275 mup_no_npvth_dn=0.737

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.351 mdn_inv_npvth=0.603
+mdn_na_ppvth_lt=-0.434 mdn_na_ppvth_rt=-0.115 mdn_na_npvth_up=0.087 mdn_na_npvth_dn=0.477
+mdn_nb_ppvth_lt=-0.219 mdn_nb_ppvth_rt=-0.300 mdn_nb_npvth_up=0.545 mdn_nb_npvth_dn=0.130
+mdn_no_ppvth_lt=-0.647 mdn_no_ppvth_rt=-0.467 mdn_no_npvth_up=0.173 mdn_no_npvth_dn=0.727
**

** 103 PUF stage
xi102 gnd net204 net205 ch_102 net206 net207 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.539 mup_inv_npvth=0.583
+mup_na_ppvth_lt=-0.168 mup_na_ppvth_rt=-0.068 mup_na_npvth_up=0.030 mup_na_npvth_dn=0.847
+mup_nb_ppvth_lt=-0.662 mup_nb_ppvth_rt=-0.679 mup_nb_npvth_up=0.393 mup_nb_npvth_dn=0.215
+mup_no_ppvth_lt=-0.667 mup_no_ppvth_rt=-0.342 mup_no_npvth_up=0.119 mup_no_npvth_dn=0.496

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.671 mdn_inv_npvth=0.176
+mdn_na_ppvth_lt=-0.136 mdn_na_ppvth_rt=-0.200 mdn_na_npvth_up=0.380 mdn_na_npvth_dn=0.825
+mdn_nb_ppvth_lt=-0.168 mdn_nb_ppvth_rt=-0.772 mdn_nb_npvth_up=0.065 mdn_nb_npvth_dn=0.559
+mdn_no_ppvth_lt=-0.445 mdn_no_ppvth_rt=-0.300 mdn_no_npvth_up=0.428 mdn_no_npvth_dn=0.625
**

** 104 PUF stage
xi103 gnd net206 net207 ch_103 net208 net209 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.080 mup_inv_npvth=0.646
+mup_na_ppvth_lt=-0.124 mup_na_ppvth_rt=-0.088 mup_na_npvth_up=0.239 mup_na_npvth_dn=0.520
+mup_nb_ppvth_lt=-0.277 mup_nb_ppvth_rt=-0.114 mup_nb_npvth_up=0.616 mup_nb_npvth_dn=0.160
+mup_no_ppvth_lt=-0.029 mup_no_ppvth_rt=-0.018 mup_no_npvth_up=0.366 mup_no_npvth_dn=0.467

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.049 mdn_inv_npvth=0.220
+mdn_na_ppvth_lt=-0.173 mdn_na_ppvth_rt=-0.054 mdn_na_npvth_up=0.116 mdn_na_npvth_dn=0.140
+mdn_nb_ppvth_lt=-0.095 mdn_nb_ppvth_rt=-0.750 mdn_nb_npvth_up=0.039 mdn_nb_npvth_dn=0.246
+mdn_no_ppvth_lt=-0.578 mdn_no_ppvth_rt=-0.725 mdn_no_npvth_up=0.037 mdn_no_npvth_dn=0.310
**

** 105 PUF stage
xi104 gnd net208 net209 ch_104 net210 net211 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.571 mup_inv_npvth=0.004
+mup_na_ppvth_lt=-0.463 mup_na_ppvth_rt=-0.306 mup_na_npvth_up=0.182 mup_na_npvth_dn=0.256
+mup_nb_ppvth_lt=-0.292 mup_nb_ppvth_rt=-0.400 mup_nb_npvth_up=0.501 mup_nb_npvth_dn=0.459
+mup_no_ppvth_lt=-0.481 mup_no_ppvth_rt=-0.600 mup_no_npvth_up=0.211 mup_no_npvth_dn=0.086

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.070 mdn_inv_npvth=0.351
+mdn_na_ppvth_lt=-0.484 mdn_na_ppvth_rt=-0.083 mdn_na_npvth_up=0.391 mdn_na_npvth_dn=0.433
+mdn_nb_ppvth_lt=-0.401 mdn_nb_ppvth_rt=-0.689 mdn_nb_npvth_up=0.322 mdn_nb_npvth_dn=0.022
+mdn_no_ppvth_lt=-0.685 mdn_no_ppvth_rt=-0.432 mdn_no_npvth_up=0.097 mdn_no_npvth_dn=0.607
**

** 106 PUF stage
xi105 gnd net210 net211 ch_105 net212 net213 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-1.313 mup_inv_npvth=0.205
+mup_na_ppvth_lt=-0.636 mup_na_ppvth_rt=-0.367 mup_na_npvth_up=0.092 mup_na_npvth_dn=0.441
+mup_nb_ppvth_lt=-0.016 mup_nb_ppvth_rt=-0.501 mup_nb_npvth_up=0.626 mup_nb_npvth_dn=0.252
+mup_no_ppvth_lt=-0.111 mup_no_ppvth_rt=-0.321 mup_no_npvth_up=0.244 mup_no_npvth_dn=1.126

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.031 mdn_inv_npvth=0.207
+mdn_na_ppvth_lt=-0.621 mdn_na_ppvth_rt=-0.347 mdn_na_npvth_up=0.258 mdn_na_npvth_dn=0.045
+mdn_nb_ppvth_lt=-0.455 mdn_nb_ppvth_rt=-0.437 mdn_nb_npvth_up=0.480 mdn_nb_npvth_dn=0.594
+mdn_no_ppvth_lt=-0.383 mdn_no_ppvth_rt=-0.236 mdn_no_npvth_up=0.305 mdn_no_npvth_dn=0.686
**

** 107 PUF stage
xi106 gnd net212 net213 ch_106 net214 net215 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.600 mup_inv_npvth=0.914
+mup_na_ppvth_lt=-0.892 mup_na_ppvth_rt=-0.083 mup_na_npvth_up=0.515 mup_na_npvth_dn=0.777
+mup_nb_ppvth_lt=-0.264 mup_nb_ppvth_rt=-0.074 mup_nb_npvth_up=0.022 mup_nb_npvth_dn=0.364
+mup_no_ppvth_lt=-0.158 mup_no_ppvth_rt=-0.551 mup_no_npvth_up=0.256 mup_no_npvth_dn=0.500

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.015 mdn_inv_npvth=0.012
+mdn_na_ppvth_lt=-0.859 mdn_na_ppvth_rt=-0.526 mdn_na_npvth_up=1.041 mdn_na_npvth_dn=0.055
+mdn_nb_ppvth_lt=-0.343 mdn_nb_ppvth_rt=-0.381 mdn_nb_npvth_up=0.419 mdn_nb_npvth_dn=0.100
+mdn_no_ppvth_lt=-0.609 mdn_no_ppvth_rt=-0.256 mdn_no_npvth_up=0.523 mdn_no_npvth_dn=0.320
**

** 108 PUF stage
xi107 gnd net214 net215 ch_107 net216 net217 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.201 mup_inv_npvth=0.581
+mup_na_ppvth_lt=-0.257 mup_na_ppvth_rt=-0.273 mup_na_npvth_up=0.763 mup_na_npvth_dn=0.165
+mup_nb_ppvth_lt=-0.200 mup_nb_ppvth_rt=-0.398 mup_nb_npvth_up=0.382 mup_nb_npvth_dn=0.218
+mup_no_ppvth_lt=-0.460 mup_no_ppvth_rt=-0.001 mup_no_npvth_up=0.442 mup_no_npvth_dn=0.525

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.425 mdn_inv_npvth=1.181
+mdn_na_ppvth_lt=-0.056 mdn_na_ppvth_rt=-0.697 mdn_na_npvth_up=0.220 mdn_na_npvth_dn=0.512
+mdn_nb_ppvth_lt=-0.042 mdn_nb_ppvth_rt=-0.624 mdn_nb_npvth_up=0.388 mdn_nb_npvth_dn=0.070
+mdn_no_ppvth_lt=-0.385 mdn_no_ppvth_rt=-0.985 mdn_no_npvth_up=0.155 mdn_no_npvth_dn=0.317
**

** 109 PUF stage
xi108 gnd net216 net217 ch_108 net218 net219 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.839 mup_inv_npvth=0.607
+mup_na_ppvth_lt=-0.033 mup_na_ppvth_rt=-0.427 mup_na_npvth_up=0.216 mup_na_npvth_dn=0.007
+mup_nb_ppvth_lt=-0.223 mup_nb_ppvth_rt=-0.536 mup_nb_npvth_up=0.631 mup_nb_npvth_dn=0.102
+mup_no_ppvth_lt=-0.506 mup_no_ppvth_rt=-0.323 mup_no_npvth_up=0.131 mup_no_npvth_dn=0.104

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.322 mdn_inv_npvth=0.446
+mdn_na_ppvth_lt=-0.291 mdn_na_ppvth_rt=-0.409 mdn_na_npvth_up=0.118 mdn_na_npvth_dn=0.883
+mdn_nb_ppvth_lt=-0.266 mdn_nb_ppvth_rt=-0.954 mdn_nb_npvth_up=0.024 mdn_nb_npvth_dn=0.133
+mdn_no_ppvth_lt=-0.251 mdn_no_ppvth_rt=-0.107 mdn_no_npvth_up=0.601 mdn_no_npvth_dn=0.737
**

** 110 PUF stage
xi109 gnd net218 net219 ch_109 net220 net221 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.114 mup_inv_npvth=0.339
+mup_na_ppvth_lt=-0.402 mup_na_ppvth_rt=-0.444 mup_na_npvth_up=0.265 mup_na_npvth_dn=0.601
+mup_nb_ppvth_lt=-0.063 mup_nb_ppvth_rt=-0.285 mup_nb_npvth_up=0.240 mup_nb_npvth_dn=0.294
+mup_no_ppvth_lt=-0.262 mup_no_ppvth_rt=-1.125 mup_no_npvth_up=0.077 mup_no_npvth_dn=0.066

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.058 mdn_inv_npvth=0.029
+mdn_na_ppvth_lt=-0.234 mdn_na_ppvth_rt=-0.069 mdn_na_npvth_up=0.300 mdn_na_npvth_dn=0.036
+mdn_nb_ppvth_lt=-0.112 mdn_nb_ppvth_rt=-0.016 mdn_nb_npvth_up=0.188 mdn_nb_npvth_dn=0.464
+mdn_no_ppvth_lt=-0.527 mdn_no_ppvth_rt=-0.251 mdn_no_npvth_up=0.228 mdn_no_npvth_dn=0.383
**

** 111 PUF stage
xi110 gnd net220 net221 ch_110 net222 net223 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.362 mup_inv_npvth=0.042
+mup_na_ppvth_lt=-0.278 mup_na_ppvth_rt=-0.478 mup_na_npvth_up=0.228 mup_na_npvth_dn=0.026
+mup_nb_ppvth_lt=-0.077 mup_nb_ppvth_rt=-0.603 mup_nb_npvth_up=0.301 mup_nb_npvth_dn=0.066
+mup_no_ppvth_lt=-0.822 mup_no_ppvth_rt=-0.386 mup_no_npvth_up=0.014 mup_no_npvth_dn=0.474

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.607 mdn_inv_npvth=0.364
+mdn_na_ppvth_lt=-0.412 mdn_na_ppvth_rt=-0.505 mdn_na_npvth_up=0.595 mdn_na_npvth_dn=0.305
+mdn_nb_ppvth_lt=-0.479 mdn_nb_ppvth_rt=-0.354 mdn_nb_npvth_up=0.646 mdn_nb_npvth_dn=0.027
+mdn_no_ppvth_lt=-0.006 mdn_no_ppvth_rt=-0.932 mdn_no_npvth_up=0.292 mdn_no_npvth_dn=0.437
**

** 112 PUF stage
xi111 gnd net222 net223 ch_111 net224 net225 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.057 mup_inv_npvth=0.396
+mup_na_ppvth_lt=-1.135 mup_na_ppvth_rt=-0.678 mup_na_npvth_up=0.031 mup_na_npvth_dn=0.038
+mup_nb_ppvth_lt=-0.829 mup_nb_ppvth_rt=-0.363 mup_nb_npvth_up=0.247 mup_nb_npvth_dn=0.130
+mup_no_ppvth_lt=-0.784 mup_no_ppvth_rt=-0.673 mup_no_npvth_up=0.156 mup_no_npvth_dn=0.796

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.407 mdn_inv_npvth=0.269
+mdn_na_ppvth_lt=-0.393 mdn_na_ppvth_rt=-0.230 mdn_na_npvth_up=0.746 mdn_na_npvth_dn=0.636
+mdn_nb_ppvth_lt=-0.911 mdn_nb_ppvth_rt=-0.061 mdn_nb_npvth_up=0.428 mdn_nb_npvth_dn=0.043
+mdn_no_ppvth_lt=-0.257 mdn_no_ppvth_rt=-0.183 mdn_no_npvth_up=0.018 mdn_no_npvth_dn=0.443
**

** 113 PUF stage
xi112 gnd net224 net225 ch_112 net226 net227 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.312 mup_inv_npvth=0.564
+mup_na_ppvth_lt=-0.047 mup_na_ppvth_rt=-0.899 mup_na_npvth_up=0.039 mup_na_npvth_dn=0.316
+mup_nb_ppvth_lt=-0.030 mup_nb_ppvth_rt=-0.072 mup_nb_npvth_up=0.694 mup_nb_npvth_dn=0.371
+mup_no_ppvth_lt=-0.445 mup_no_ppvth_rt=-0.001 mup_no_npvth_up=0.433 mup_no_npvth_dn=0.111

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.536 mdn_inv_npvth=0.305
+mdn_na_ppvth_lt=-0.341 mdn_na_ppvth_rt=-0.639 mdn_na_npvth_up=0.058 mdn_na_npvth_dn=1.056
+mdn_nb_ppvth_lt=-0.696 mdn_nb_ppvth_rt=-0.035 mdn_nb_npvth_up=0.179 mdn_nb_npvth_dn=0.282
+mdn_no_ppvth_lt=-0.435 mdn_no_ppvth_rt=-0.204 mdn_no_npvth_up=0.670 mdn_no_npvth_dn=0.041
**

** 114 PUF stage
xi113 gnd net226 net227 ch_113 net228 net229 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.382 mup_inv_npvth=0.435
+mup_na_ppvth_lt=-0.388 mup_na_ppvth_rt=-0.082 mup_na_npvth_up=0.042 mup_na_npvth_dn=0.019
+mup_nb_ppvth_lt=-0.290 mup_nb_ppvth_rt=-0.108 mup_nb_npvth_up=0.054 mup_nb_npvth_dn=0.718
+mup_no_ppvth_lt=-0.389 mup_no_ppvth_rt=-0.538 mup_no_npvth_up=0.133 mup_no_npvth_dn=0.368

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.225 mdn_inv_npvth=0.300
+mdn_na_ppvth_lt=-0.184 mdn_na_ppvth_rt=-0.286 mdn_na_npvth_up=0.418 mdn_na_npvth_dn=0.485
+mdn_nb_ppvth_lt=-0.455 mdn_nb_ppvth_rt=-0.639 mdn_nb_npvth_up=0.166 mdn_nb_npvth_dn=0.491
+mdn_no_ppvth_lt=-0.536 mdn_no_ppvth_rt=-0.820 mdn_no_npvth_up=0.668 mdn_no_npvth_dn=0.217
**

** 115 PUF stage
xi114 gnd net228 net229 ch_114 net230 net231 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.365 mup_inv_npvth=0.226
+mup_na_ppvth_lt=-0.251 mup_na_ppvth_rt=-0.143 mup_na_npvth_up=0.485 mup_na_npvth_dn=0.365
+mup_nb_ppvth_lt=-0.264 mup_nb_ppvth_rt=-0.805 mup_nb_npvth_up=0.598 mup_nb_npvth_dn=0.173
+mup_no_ppvth_lt=-0.586 mup_no_ppvth_rt=-0.946 mup_no_npvth_up=0.327 mup_no_npvth_dn=0.725

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.047 mdn_inv_npvth=0.628
+mdn_na_ppvth_lt=-0.371 mdn_na_ppvth_rt=-0.134 mdn_na_npvth_up=0.216 mdn_na_npvth_dn=0.249
+mdn_nb_ppvth_lt=-0.124 mdn_nb_ppvth_rt=-0.078 mdn_nb_npvth_up=0.344 mdn_nb_npvth_dn=0.184
+mdn_no_ppvth_lt=-0.420 mdn_no_ppvth_rt=-0.178 mdn_no_npvth_up=0.073 mdn_no_npvth_dn=0.352
**

** 116 PUF stage
xi115 gnd net230 net231 ch_115 net232 net233 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.205 mup_inv_npvth=0.268
+mup_na_ppvth_lt=-1.017 mup_na_ppvth_rt=-0.163 mup_na_npvth_up=0.174 mup_na_npvth_dn=0.099
+mup_nb_ppvth_lt=-0.121 mup_nb_ppvth_rt=-0.277 mup_nb_npvth_up=0.057 mup_nb_npvth_dn=0.908
+mup_no_ppvth_lt=-0.020 mup_no_ppvth_rt=-0.004 mup_no_npvth_up=0.145 mup_no_npvth_dn=0.462

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.114 mdn_inv_npvth=0.861
+mdn_na_ppvth_lt=-0.503 mdn_na_ppvth_rt=-0.640 mdn_na_npvth_up=0.460 mdn_na_npvth_dn=0.128
+mdn_nb_ppvth_lt=-0.058 mdn_nb_ppvth_rt=-0.519 mdn_nb_npvth_up=0.344 mdn_nb_npvth_dn=0.145
+mdn_no_ppvth_lt=-0.143 mdn_no_ppvth_rt=-0.414 mdn_no_npvth_up=0.052 mdn_no_npvth_dn=0.181
**

** 117 PUF stage
xi116 gnd net232 net233 ch_116 net234 net235 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.209 mup_inv_npvth=0.674
+mup_na_ppvth_lt=-0.218 mup_na_ppvth_rt=-0.372 mup_na_npvth_up=0.414 mup_na_npvth_dn=0.241
+mup_nb_ppvth_lt=-0.499 mup_nb_ppvth_rt=-1.125 mup_nb_npvth_up=0.689 mup_nb_npvth_dn=0.297
+mup_no_ppvth_lt=-0.665 mup_no_ppvth_rt=-0.375 mup_no_npvth_up=0.603 mup_no_npvth_dn=0.622

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.600 mdn_inv_npvth=0.492
+mdn_na_ppvth_lt=-0.102 mdn_na_ppvth_rt=-0.145 mdn_na_npvth_up=0.499 mdn_na_npvth_dn=0.552
+mdn_nb_ppvth_lt=-0.553 mdn_nb_ppvth_rt=-0.129 mdn_nb_npvth_up=0.342 mdn_nb_npvth_dn=0.815
+mdn_no_ppvth_lt=-0.336 mdn_no_ppvth_rt=-0.008 mdn_no_npvth_up=0.482 mdn_no_npvth_dn=0.123
**

** 118 PUF stage
xi117 gnd net234 net235 ch_117 net236 net237 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.444 mup_inv_npvth=0.738
+mup_na_ppvth_lt=-0.423 mup_na_ppvth_rt=-0.050 mup_na_npvth_up=0.372 mup_na_npvth_dn=0.063
+mup_nb_ppvth_lt=-0.577 mup_nb_ppvth_rt=-0.001 mup_nb_npvth_up=0.293 mup_nb_npvth_dn=0.429
+mup_no_ppvth_lt=-0.805 mup_no_ppvth_rt=-0.154 mup_no_npvth_up=0.155 mup_no_npvth_dn=0.176

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.238 mdn_inv_npvth=0.264
+mdn_na_ppvth_lt=-0.448 mdn_na_ppvth_rt=-0.031 mdn_na_npvth_up=0.327 mdn_na_npvth_dn=0.120
+mdn_nb_ppvth_lt=-0.146 mdn_nb_ppvth_rt=-0.129 mdn_nb_npvth_up=0.889 mdn_nb_npvth_dn=0.297
+mdn_no_ppvth_lt=-0.170 mdn_no_ppvth_rt=-0.034 mdn_no_npvth_up=0.356 mdn_no_npvth_dn=0.164
**

** 119 PUF stage
xi118 gnd net236 net237 ch_118 net238 net239 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.275 mup_inv_npvth=0.082
+mup_na_ppvth_lt=-0.358 mup_na_ppvth_rt=-0.184 mup_na_npvth_up=0.807 mup_na_npvth_dn=0.418
+mup_nb_ppvth_lt=-0.062 mup_nb_ppvth_rt=-0.578 mup_nb_npvth_up=0.438 mup_nb_npvth_dn=0.548
+mup_no_ppvth_lt=-0.042 mup_no_ppvth_rt=-0.007 mup_no_npvth_up=0.046 mup_no_npvth_dn=0.387

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.000 mdn_inv_npvth=0.632
+mdn_na_ppvth_lt=-0.520 mdn_na_ppvth_rt=-0.191 mdn_na_npvth_up=0.732 mdn_na_npvth_dn=0.067
+mdn_nb_ppvth_lt=-0.459 mdn_nb_ppvth_rt=-0.725 mdn_nb_npvth_up=0.091 mdn_nb_npvth_dn=0.651
+mdn_no_ppvth_lt=-0.074 mdn_no_ppvth_rt=-0.818 mdn_no_npvth_up=0.291 mdn_no_npvth_dn=0.801
**

** 120 PUF stage
xi119 gnd net238 net239 ch_119 net240 net241 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.009 mup_inv_npvth=0.455
+mup_na_ppvth_lt=-0.187 mup_na_ppvth_rt=-0.847 mup_na_npvth_up=0.219 mup_na_npvth_dn=0.000
+mup_nb_ppvth_lt=-0.192 mup_nb_ppvth_rt=-0.203 mup_nb_npvth_up=0.081 mup_nb_npvth_dn=0.470
+mup_no_ppvth_lt=-0.115 mup_no_ppvth_rt=-0.211 mup_no_npvth_up=0.267 mup_no_npvth_dn=0.543

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.132 mdn_inv_npvth=0.340
+mdn_na_ppvth_lt=-0.209 mdn_na_ppvth_rt=-0.456 mdn_na_npvth_up=0.165 mdn_na_npvth_dn=0.338
+mdn_nb_ppvth_lt=-0.809 mdn_nb_ppvth_rt=-0.657 mdn_nb_npvth_up=0.385 mdn_nb_npvth_dn=0.937
+mdn_no_ppvth_lt=-0.334 mdn_no_ppvth_rt=-0.835 mdn_no_npvth_up=0.471 mdn_no_npvth_dn=0.225
**

** 121 PUF stage
xi120 gnd net240 net241 ch_120 net242 net243 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.182 mup_inv_npvth=0.365
+mup_na_ppvth_lt=-0.446 mup_na_ppvth_rt=-0.077 mup_na_npvth_up=0.223 mup_na_npvth_dn=0.799
+mup_nb_ppvth_lt=-0.224 mup_nb_ppvth_rt=-0.496 mup_nb_npvth_up=0.086 mup_nb_npvth_dn=1.084
+mup_no_ppvth_lt=-0.733 mup_no_ppvth_rt=-0.726 mup_no_npvth_up=0.144 mup_no_npvth_dn=0.415

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.776 mdn_inv_npvth=0.188
+mdn_na_ppvth_lt=-0.736 mdn_na_ppvth_rt=-0.180 mdn_na_npvth_up=0.310 mdn_na_npvth_dn=1.059
+mdn_nb_ppvth_lt=-0.588 mdn_nb_ppvth_rt=-0.970 mdn_nb_npvth_up=0.446 mdn_nb_npvth_dn=0.016
+mdn_no_ppvth_lt=-0.450 mdn_no_ppvth_rt=-0.236 mdn_no_npvth_up=1.066 mdn_no_npvth_dn=0.399
**

** 122 PUF stage
xi121 gnd net242 net243 ch_121 net244 net245 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.520 mup_inv_npvth=0.073
+mup_na_ppvth_lt=-0.402 mup_na_ppvth_rt=-0.042 mup_na_npvth_up=0.510 mup_na_npvth_dn=0.112
+mup_nb_ppvth_lt=-0.313 mup_nb_ppvth_rt=-0.329 mup_nb_npvth_up=0.125 mup_nb_npvth_dn=0.229
+mup_no_ppvth_lt=-0.278 mup_no_ppvth_rt=-0.077 mup_no_npvth_up=0.053 mup_no_npvth_dn=0.322

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.606 mdn_inv_npvth=0.459
+mdn_na_ppvth_lt=-0.080 mdn_na_ppvth_rt=-0.429 mdn_na_npvth_up=0.133 mdn_na_npvth_dn=0.267
+mdn_nb_ppvth_lt=-0.322 mdn_nb_ppvth_rt=-0.258 mdn_nb_npvth_up=0.344 mdn_nb_npvth_dn=0.230
+mdn_no_ppvth_lt=-0.348 mdn_no_ppvth_rt=-0.705 mdn_no_npvth_up=0.017 mdn_no_npvth_dn=0.026
**

** 123 PUF stage
xi122 gnd net244 net245 ch_122 net246 net247 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.587 mup_inv_npvth=0.205
+mup_na_ppvth_lt=-0.372 mup_na_ppvth_rt=-0.419 mup_na_npvth_up=0.054 mup_na_npvth_dn=0.727
+mup_nb_ppvth_lt=-0.102 mup_nb_ppvth_rt=-0.154 mup_nb_npvth_up=0.130 mup_nb_npvth_dn=0.560
+mup_no_ppvth_lt=-0.820 mup_no_ppvth_rt=-0.485 mup_no_npvth_up=0.134 mup_no_npvth_dn=0.675

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.386 mdn_inv_npvth=0.110
+mdn_na_ppvth_lt=-0.327 mdn_na_ppvth_rt=-0.802 mdn_na_npvth_up=0.070 mdn_na_npvth_dn=0.095
+mdn_nb_ppvth_lt=-0.633 mdn_nb_ppvth_rt=-0.437 mdn_nb_npvth_up=0.267 mdn_nb_npvth_dn=0.207
+mdn_no_ppvth_lt=-0.283 mdn_no_ppvth_rt=-0.049 mdn_no_npvth_up=0.126 mdn_no_npvth_dn=0.127
**

** 124 PUF stage
xi123 gnd net246 net247 ch_123 net248 net249 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.638 mup_inv_npvth=0.064
+mup_na_ppvth_lt=-1.265 mup_na_ppvth_rt=-0.498 mup_na_npvth_up=0.047 mup_na_npvth_dn=0.232
+mup_nb_ppvth_lt=-0.374 mup_nb_ppvth_rt=-0.204 mup_nb_npvth_up=0.980 mup_nb_npvth_dn=0.449
+mup_no_ppvth_lt=-0.573 mup_no_ppvth_rt=-0.454 mup_no_npvth_up=0.642 mup_no_npvth_dn=0.672

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.136 mdn_inv_npvth=0.174
+mdn_na_ppvth_lt=-0.428 mdn_na_ppvth_rt=-0.021 mdn_na_npvth_up=0.402 mdn_na_npvth_dn=1.030
+mdn_nb_ppvth_lt=-0.107 mdn_nb_ppvth_rt=-0.519 mdn_nb_npvth_up=0.812 mdn_nb_npvth_dn=0.666
+mdn_no_ppvth_lt=-0.257 mdn_no_ppvth_rt=-1.078 mdn_no_npvth_up=0.252 mdn_no_npvth_dn=0.268
**

** 125 PUF stage
xi124 gnd net248 net249 ch_124 net250 net251 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.169 mup_inv_npvth=0.354
+mup_na_ppvth_lt=-0.183 mup_na_ppvth_rt=-0.362 mup_na_npvth_up=0.294 mup_na_npvth_dn=0.115
+mup_nb_ppvth_lt=-0.486 mup_nb_ppvth_rt=-0.370 mup_nb_npvth_up=0.084 mup_nb_npvth_dn=0.084
+mup_no_ppvth_lt=-0.337 mup_no_ppvth_rt=-0.746 mup_no_npvth_up=0.029 mup_no_npvth_dn=0.080

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.619 mdn_inv_npvth=0.325
+mdn_na_ppvth_lt=-0.735 mdn_na_ppvth_rt=-0.173 mdn_na_npvth_up=0.692 mdn_na_npvth_dn=0.323
+mdn_nb_ppvth_lt=-0.602 mdn_nb_ppvth_rt=-0.262 mdn_nb_npvth_up=0.108 mdn_nb_npvth_dn=0.066
+mdn_no_ppvth_lt=-0.139 mdn_no_ppvth_rt=-0.241 mdn_no_npvth_up=0.225 mdn_no_npvth_dn=0.602
**

** 126 PUF stage
xi125 gnd net250 net251 ch_125 net252 net253 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.610 mup_inv_npvth=0.329
+mup_na_ppvth_lt=-0.419 mup_na_ppvth_rt=-0.116 mup_na_npvth_up=0.234 mup_na_npvth_dn=0.013
+mup_nb_ppvth_lt=-0.456 mup_nb_ppvth_rt=-0.041 mup_nb_npvth_up=0.129 mup_nb_npvth_dn=0.082
+mup_no_ppvth_lt=-0.106 mup_no_ppvth_rt=-0.039 mup_no_npvth_up=0.396 mup_no_npvth_dn=0.028

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.140 mdn_inv_npvth=0.500
+mdn_na_ppvth_lt=-0.343 mdn_na_ppvth_rt=-0.003 mdn_na_npvth_up=0.120 mdn_na_npvth_dn=0.707
+mdn_nb_ppvth_lt=-0.113 mdn_nb_ppvth_rt=-0.450 mdn_nb_npvth_up=0.207 mdn_nb_npvth_dn=0.360
+mdn_no_ppvth_lt=-0.377 mdn_no_ppvth_rt=-0.131 mdn_no_npvth_up=0.159 mdn_no_npvth_dn=0.099
**

** 127 PUF stage
xi126 gnd net252 net253 ch_126 net254 net255 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.760 mup_inv_npvth=0.085
+mup_na_ppvth_lt=-0.150 mup_na_ppvth_rt=-0.184 mup_na_npvth_up=0.419 mup_na_npvth_dn=0.789
+mup_nb_ppvth_lt=-0.318 mup_nb_ppvth_rt=-0.226 mup_nb_npvth_up=0.380 mup_nb_npvth_dn=0.475
+mup_no_ppvth_lt=-0.391 mup_no_ppvth_rt=-0.211 mup_no_npvth_up=0.324 mup_no_npvth_dn=0.096

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.027 mdn_inv_npvth=0.612
+mdn_na_ppvth_lt=-0.105 mdn_na_ppvth_rt=-0.637 mdn_na_npvth_up=0.135 mdn_na_npvth_dn=0.661
+mdn_nb_ppvth_lt=-0.515 mdn_nb_ppvth_rt=-0.317 mdn_nb_npvth_up=0.445 mdn_nb_npvth_dn=0.442
+mdn_no_ppvth_lt=-0.127 mdn_no_ppvth_rt=-0.051 mdn_no_npvth_up=0.047 mdn_no_npvth_dn=0.505
**

** 128 PUF stage
xi127 gnd net254 net255 ch_127 net256 net257 vdd puf_stage
** Vt parameters of the upper MUX2x1
+mup_inv_ppvth=-0.224 mup_inv_npvth=0.237
+mup_na_ppvth_lt=-0.698 mup_na_ppvth_rt=-0.679 mup_na_npvth_up=0.534 mup_na_npvth_dn=0.676
+mup_nb_ppvth_lt=-0.510 mup_nb_ppvth_rt=-0.280 mup_nb_npvth_up=0.484 mup_nb_npvth_dn=0.402
+mup_no_ppvth_lt=-0.421 mup_no_ppvth_rt=-0.154 mup_no_npvth_up=0.325 mup_no_npvth_dn=0.457

** Vt parameters of the lower MUX2x1
+mdn_inv_ppvth=-0.293 mdn_inv_npvth=0.232
+mdn_na_ppvth_lt=-0.020 mdn_na_ppvth_rt=-0.346 mdn_na_npvth_up=0.048 mdn_na_npvth_dn=0.041
+mdn_nb_ppvth_lt=-0.173 mdn_nb_ppvth_rt=-0.359 mdn_nb_npvth_up=0.341 mdn_nb_npvth_dn=0.038
+mdn_no_ppvth_lt=-0.027 mdn_no_ppvth_rt=-0.106 mdn_no_npvth_up=0.446 mdn_no_npvth_dn=0.002
**

** SR latch
xi128 gnd q net258 net256 net257 vdd sr_latch
.ends puf_0
** End of subcircuit definition

.end
